Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[SteelFabricationView]
File name: Einzelbalkon mit Zugangstreppe Bonn_em11.ifc
Time: 2026-07-13T14:27:22
Written by: IFC Toolkit 2.0.26.0
Made in: Advance Steel 2024

# IfcBuildingStorey, Default Storey
In: Struktur 1
Elevation: 0 mm

# IfcBeam: - (25)
In: Default Storey
Pset_BeamCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material | Reference = PieceMark | Span (mm) | MaterialID | MaterialType | SequentialOrder
- | Rinnenprofil 130x5 | S235JR | 26 | 2920 | S235JR | Steel | feuerverzinkt
6 x - | Gummistreifen 60x3 | Gummi | 5 | 200 | Rubber | Others | feuerverzinkt
6 x - | L 200x100x10 | Alu | 10 | 60 | AL | Others | feuerverzinkt
- | L60X40X5 | S235JR | 19 | 1340 | S235JR | Steel | feuerverzinkt
- | R50X30X3 | S235JR | 23 | 3139.58 | S235JR | Steel | feuerverzinkt
8 x - |  | S235JR | 2 | 1340 | S235JR | Steel | keine
- | G 200x5 (Typ III) | S355JR | 18 | 2940 | S355JR | Steel | feuerverzinkt
- | R50X30X3 | S235JR | 24 | 2820 | S235JR | Steel | feuerverzinkt

# IfcBeam: Girder (8)
In: Default Storey
Material: S235JR
Pset_BeamCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Description | Reference = PieceMark | Span (mm)
Girder | RO82.5x5 (Mannesmann) | 1 | 220
2 x Girder | RO70x5 (Mannesmann) | 7 | 160
Girder | RO82.5x5 (Mannesmann) | 6 | 220
2 x Girder | RO70x5 (Mannesmann) | 8 | 174.999
2 x Girder | RO82.5x5 (Mannesmann) | 3 | 220

# IfcColumn: - (5)
In: Default Storey
Pset_ColumnCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Description | Material | Reference = PieceMark | MaterialID
2 x - | Q100X4 | S235JR | 15 | S235JR
- | Q100X4 | S235JR | 21 | S235JR
- | RO50x2.5 | A500 GR.C | 22 | ASTMA500GRC
- | Q100X4 | S235JR | 20 | S235JR

# IfcDiscreteAccessory: - (237)
In: Default Storey
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material | PieceMark | MaterialID | SequentialOrder
- | Q90X4 | S235JR | 439 | S235JR | feuerverzinkt
5 x - | Q90X4 | S235JR | 415 | S235JR | feuerverzinkt
- | Q100X4 | S235JR | 435 | S235JR | feuerverzinkt
- | Q100X4 | S235JR | 436 | S235JR | feuerverzinkt
- | Q100X4 | S235JR | 437 | S235JR | feuerverzinkt
4 x - | Q60X3 | S235JR | 417 | S235JR | feuerverzinkt
- | Q50X4 | S235JR | 438 | S235JR | feuerverzinkt
9 x - | FL75X6 | S235JR | 414 | S235JR | feuerverzinkt
- | R40X30X3 | S235JR | 444 | S235JR | feuerverzinkt
2 x - | Q100X4 | S235JR | 425 | S235JR | feuerverzinkt
3 x - | RHS80X60X4 | S235JR | 423 | S235JR | feuerverzinkt
16 x - | FL40X5 | S235JR | 412 | S235JR | feuerverzinkt
- | C-Profil 217x30x4 | S235JR | 427 | S235JR | feuerverzinkt
- | C-Profil 217x30x4 | S235JR | 429 | S235JR | feuerverzinkt
- | C-Profil 217x30x4 | S235JR | 428 | S235JR | feuerverzinkt
- | C-Profil 217x30x4 | S235JR | 430 | S235JR | feuerverzinkt
2 x - | R40X30X3 | S235JR | 426 | S235JR | feuerverzinkt
4 x - | R40X30X3 | S235JR | 419 | S235JR | feuerverzinkt
- | R50X30X3 | S235JR | 445 | S235JR | feuerverzinkt
4 x - | R30X20X2 | S235JR | 418 | S235JR | feuerverzinkt
- | R30X20X2 | S235JR | 440 | S235JR | feuerverzinkt
- | R30X20X2 | S235JR | 442 | S235JR | feuerverzinkt
37 x - | RD12 | S235JR | 402 | S235JR | feuerverzinkt
- | R30X20X2 | S235JR | 443 | S235JR | feuerverzinkt
32 x - | RD12 | S235JR | 403 | S235JR | feuerverzinkt
- | R30X20X2 | S235JR | 441 | S235JR | feuerverzinkt
- | R50X30X3 | S235JR | 446 | S235JR | feuerverzinkt
19 x - | FL80X6 | S235JR | 404 | S235JR | feuerverzinkt
- | RHS?48.3x2 | S235JR | 449 | S235JR | feuerverzinkt
9 x - | FL40X5 | S235JR | 413 | S235JR | feuerverzinkt
2 x - | FL40X5 | S235JR | 424 | S235JR | feuerverzinkt
- | G 200x5 (Typ III) | S355JR | 431 | S355JR | feuerverzinkt
- | G 200x5 (Typ III) | S355JR | 432 | S355JR | feuerverzinkt
- | G 200x5 (Typ III) | S355JR | 433 | S355JR | feuerverzinkt
- | Hutprofil 100x5 | S355JR | 434 | S355JR | feuerverzinkt
3 x - | R40X30X3 | S235JR | 422 | S235JR | feuerverzinkt
5 x - | R40X30X3 | S235JR | 416 | S235JR | feuerverzinkt
3 x - | R30X20X2 | S235JR | 420 | S235JR | feuerverzinkt
3 x - | R30X20X2 | S235JR | 421 | S235JR | feuerverzinkt
- | RHS?42.4x2.6 | S235JR | 447 | S235JR | feuerverzinkt
- | RHS?42.4x2.6 | S235JR | 448 | S235JR | feuerverzinkt
2 x - | - | S235JR 10 mm | 452 | S235JR | keine
8 x - | - | S235JR 6 mm | 451 | S235JR | keine
- | - | S235JR 5 mm | 459 | S235JR | keine
2 x - | - | S235JR 5 mm | 457 | S235JR | keine
- | - | S235JR 5 mm | 460 | S235JR | keine
16 x - | - | S235JR 5 mm | 450 | S235JR | keine
- | - | S235JR 10 mm | 400 | S235JR | keine
2 x - | - | S355JR 15 mm | 409 | S355JR | keine
4 x - | - | S355JR 15 mm | 408 | S355JR | keine
- | - | S355JR 15 mm | 401 | S355JR | keine
- | - | S355JR 15 mm | 406 | S355JR | keine
2 x - | - | S355JR 15 mm | 410 | S355JR | keine
2 x - | - | S355JR 15 mm | 405 | S355JR | keine
2 x - | - | S235JR 5 mm | 456 | S235JR | keine
2 x - | - | S235JR 10 mm | 455 | S235JR | keine
2 x - | - | S235JR 10 mm | 454 | S235JR | keine
2 x - | - | S235JR 10 mm | 453 | S235JR | keine
- | - | S235JR 3 mm | 458 | S235JR | keine

# IfcElementAssembly: Steel Assembly (76)
In: Default Storey
AssemblyPlace: FACTORY
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Material | PieceMark | MaterialID | MaterialType
2 x  | S235JR | 15 | S235JR | Steel
 | S235JR | 21 | S235JR | Steel
 | A500 GR.C | 22 | ASTMA500GRC | Steel
 | S235JR | 26 | S235JR | Steel
2 x  | Alu | 14 | AL | Others
6 x  | S235JR | 11 | S235JR | Steel
6 x  | S235JR | 4 | S235JR | Steel
6 x  | Gummi | 5 | Rubber | Others
 | S235JR | 1 | S235JR | Steel
2 x  | S235JR | 7 | S235JR | Steel
 | S235JR | 6 | S235JR | Steel
2 x  | S235JR | 8 | S235JR | Steel
2 x  | S235JR | 3 | S235JR | Steel
6 x  | Alu | 10 | AL | Others
 | S235JR | 19 | S235JR | Steel
 | S235JR | 16 | S235JR | Steel
 | S235JR | 17 | S235JR | Steel
 | S235JR | 23 | S235JR | Steel
 | S235JR | 25 | S235JR | Steel
8 x  | S235JR | 2 | S235JR | Steel
 | S355JR | 18 | S355JR | Steel
 | S235JR | 24 | S235JR | Steel
 | S235JR | 20 | S235JR | Steel
5 x  | Glas 8.76 mm | 38 | Glass | Others
8 x  | Mineralit 35 mm | 32
 | Alu 5 mm | 47 | AL | Others
 | Thermostop 6 mm | 9
 | Thermostop 6 mm | 13
2 x  | Thermostop 6 mm | 12
 | Mineralit 35 mm | 46
2 x  | Mineralit 35 mm | 44

# IfcFastener: Weld (277)
In: Default Storey
AISC_EM11_Pset_Weld - Type1: Kehlnaht; a: 0 mm; l: 0 mm; s: 3 mm; WeldDescription: Weld; FieldWeld: no

# IfcMechanicalFastener: - (94)
In: Default Storey
Name | NominalDiameter (mm) | NominalLength (mm) | BoltStandard | BoltType | BoltGrade | BoltDiameter (mm) | BoltLength (mm) | BoltFieldAssembled | SequentialOrder
6 x  | 8 | 20 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 8 | 20 | yes | Edelstahl A2
24 x  | 6 | 40 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 6 | 40 | yes | Edelstahl A2
4 x  | 12 | 120 |  |  |  |  |  |  | Edelstahl A4
2 x  | 16 | 40 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | 16 | 40 | yes | Feuerverzinkt
2 x  | 16 | 140 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 16 | 140 | yes | Edelstahl A2
31 x  | 12 | 40 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 12 | 40 | yes | Edelstahl A2
2 x  | 12 | 130 |  |  |  |  |  |  | Edelstahl A4
17 x  | 12 | 70 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 12 | 70 | yes | Edelstahl A2
 | 8 | 55 | ISO 4017 | DIN 7991 | A2-70 | 8 | 55 | yes | Edelstahl A2
4 x  | 12 | 65 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 12 | 65 | yes | Edelstahl A2
 | 12 | 80 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 12 | 80 | yes | Edelstahl A2

# IfcMember: - (17)
In: Default Storey
Pset_MemberCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Description | Material | Reference = PieceMark | Span (mm) | MaterialID | MaterialType
2 x - | FL20X8 | Alu | 14 | 954.996 | AL | Others
6 x - | Weichgummistreifen f?r Dachbelag 50x3 | S235JR | 11 | 904.996 | S235JR | Steel
6 x - | Abdeckleiste f?r Dachbelag 50x5 | S235JR | 4 | 954.996 | S235JR | Steel
- | C-Profil 217x30x4 | S235JR | 16 | 2564.55 | S235JR | Steel
- | C-Profil 217x30x4 | S235JR | 17 | 2564.55 | S235JR | Steel
- | R50X30X3 | S235JR | 25 | 2621.54 | S235JR | Steel

# IfcPlate: - (21)
In: Default Storey
Description: -
Pset_PlateCommon - IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Material | Reference = PieceMark | SequentialOrder
5 x - | Glas 8.76 mm | 38 | keine | AISC_EM11_Pset_Material - MaterialID: Glass; MaterialType: Others
8 x - | Mineralit 35 mm | 32 | keine
- | Alu 5 mm | 47 | roh | AISC_EM11_Pset_Material - MaterialID: AL; MaterialType: Others
- | Thermostop 6 mm | 9 | keine
- | Thermostop 6 mm | 13 | keine
2 x - | Thermostop 6 mm | 12 | keine
- | Mineralit 35 mm | 46 | keine
2 x - | Mineralit 35 mm | 44 | keine
