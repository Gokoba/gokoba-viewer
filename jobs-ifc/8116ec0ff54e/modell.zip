Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[SteelFabricationView]
File name: Treppenhausgel?nder TZ Dresden_em11.ifc
Time: 2026-07-12T18:14:00
Written by: IFC Toolkit 2.0.26.0
Made in: Advance Steel 2024

# IfcBuildingStorey, Default Storey
In: Struktur 1
Elevation: 0 mm

# IfcBeam: Gel?nder (11)
In: Default Storey
Description: FL50X10; Material: S235JR
Pset_BeamCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: beschichtet RAL 7016
Name | Reference = PieceMark | Span (mm)
Gel?nder | 117 | 312.5
Gel?nder | 76 | 697.496
Gel?nder | 111 | 209.996
Gel?nder | 102 | 214.996
2 x Gel?nder | 66 | 232.5
Gel?nder | 118 | 1225
Gel?nder | 115 | 960.496
2 x Gel?nder | 74 | 177.5
Gel?nder | 99 | 187.5

# IfcBeam: Girder (31)
In: Default Storey
Description: RD40; Material: Buche
Pset_BeamCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: Beech; MaterialType: Timber
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: keine
Name | Reference = PieceMark | Span (mm)
Girder | 7 | 89.6687
Girder | 7 | 89.6743
Girder | 7 | 89.6653
Girder | 23 | 1304.99
Girder | 25 | 489.995
Girder | 26 | 494.994
3 x Girder | 2 | 89.9986
Girder | 41 | 1368
2 x Girder | 4 | 79.6687
Girder | 4 | 79.6743
Girder | 4 | 79.6653
Girder | 45 | 559.998
Girder | 8 | 574.999
Girder | 46 | 1389.99
Girder | 8 | 574.995
Girder | 47 | 579.994
6 x Girder | 1 | 79.9986
Girder | 4 | 79.6709
Girder | 4 | 79.6681
Girder | 59 | 1720
Girder | 12 | 539.999
Girder | 13 | 555
Girder | 11 | 1348

# IfcDiscreteAccessory: - (532)
In: Default Storey
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: beschichtet RAL 7016
Name | Description | Material | PieceMark
120 x - | RD10 | S235JR | 301
202 x - | RD10 | S235JR | 300
9 x - | FL50X15 | S235JR | 303
52 x - | FL50X15 | S235JR | 302
8 x - | FL50X15 | S235JR | 307
- | FL50X10 | S235JR | 365
- | FL50X10 | S235JR | 332
8 x - | FL50X10 | S235JR | 304
- | FL50X10 | S235JR | 343
- | RD10 | S235JR | 387
- | FL50X10 | S235JR | 376
- | RD10 | S235JR | 388
3 x - | FL50X15 | S235JR | 315
3 x - | FL50X15 | S235JR | 313
2 x - | FL50X15 | S235JR | 318
2 x - | FL50X15 | S235JR | 312
- | FL50X10 | S235JR | 372
5 x - | FL50X10 | S235JR | 308
- | FL50X10 | S235JR | 368
- | FL50X10 | S235JR | 324
- | FL50X10 | S235JR | 322
- | FL50X15 | S235JR | 344
5 x - | FL50X15 | S235JR | 306
5 x - | FL50X15 | S235JR | 305
- | FL50X15 | S235JR | 381
- | FL50X15 | S235JR | 380
2 x - | FL50X15 | S235JR | 316
2 x - | FL50X15 | S235JR | 314
2 x - | FL50X15 | S235JR | 328
2 x - | FL50X15 | S235JR | 326
- | FL50X15 | S235JR | 346
- | FL50X15 | S235JR | 384
- | FL50X15 | S235JR | 382
3 x - | FL50X10 | S235JR | 310
2 x - | FL50X10 | S235JR | 342
- | FL50X10 | S235JR | 351
- | FL50X10 | S235JR | 374
5 x - | FL50X10 | S235JR | 309
- | FL50X10 | S235JR | 357
- | FL50X10 | S235JR | 334
- | FL50X10 | S235JR | 333
- | FL50X10 | S235JR | 379
3 x - | FL50X15 | S235JR | 329
3 x - | RD10 | S235JR | 311
2 x - | FL50X10 | S235JR | 317
- | FL50X10 | S235JR | 353
3 x - | FL50X15 | S235JR | 327
2 x - | FL50X10 | S235JR | 340
- | FL50X10 | S235JR | 371
- | RD10 | S235JR | 389
3 x - | FL50X15 | S235JR | 319
- | FL50X10 | S235JR | 325
- | FL50X10 | S235JR | 323
- | RD10 | S235JR | 331
- | FL50X10 | S235JR | 378
- | FL50X10 | S235JR | 369
- | FL50X10 | S235JR | 339
- | RD10 | S235JR | 390
- | FL50X10 | S235JR | 359
- | FL50X10 | S235JR | 367
- | FL50X10 | S235JR | 361
- | FL50X10 | S235JR | 321
- | FL50X10 | S235JR | 360
- | FL50X10 | S235JR | 352
- | FL50X10 | S235JR | 350
2 x - | FL50X10 | S235JR | 336
- | FL50X10 | S235JR | 348
- | FL50X10 | S235JR | 335
- | FL50X10 | S235JR | 363
6 x - | - | S235JR 10 mm | 393
18 x - | - | S235JR 10 mm | 392
6 x - | - | S235JR 10 mm | 394

# IfcDiscreteAccessory: Girder (127)
In: Default Storey
Description: -
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: beschichtet RAL 7016
Name | Material | PieceMark
49 x Girder | S235JR 15 mm | 396
71 x Girder | S235JR 10 mm | 402
3 x Girder | S235JR 10 mm | 403
Girder | S235JR 15 mm | 397
3 x Girder | S235JR 10 mm | 395

# IfcElementAssembly: Steel Assembly (255)
In: Default Storey
AssemblyPlace: FACTORY
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Material | PieceMark | MaterialID | MaterialType
3 x  | Buche | 7 | Beech | Timber
 | S235JR | 117 | S235JR | Steel
 | S235JR | 76 | S235JR | Steel
 | Buche | 23 | Beech | Timber
 | S235JR | 111 | S235JR | Steel
 | Buche | 25 | Beech | Timber
 | S235JR | 102 | S235JR | Steel
 | Buche | 26 | Beech | Timber
 | S235JR | 110 | S235JR | Steel
 | S235JR | 68 | S235JR | Steel
 | S235JR | 109 | S235JR | Steel
 | S235JR | 108 | S235JR | Steel
 | S235JR | 107 | S235JR | Steel
 | S235JR | 73 | S235JR | Steel
 | S235JR | 101 | S235JR | Steel
 | S235JR | 100 | S235JR | Steel
 | Buche | 27 | Beech | Timber
 | Buche | 28 | Beech | Timber
 | Buche | 29 | Beech | Timber
 | S235JR | 72 | S235JR | Steel
 | S235JR | 75 | S235JR | Steel
 | S235JR | 116 | S235JR | Steel
3 x  | Buche | 2 | Beech | Timber
 | Buche | 41 | Beech | Timber
 | Buche | 42 | Beech | Timber
 | Buche | 43 | Beech | Timber
 | Buche | 44 | Beech | Timber
6 x  | Buche | 4 | Beech | Timber
 | Buche | 45 | Beech | Timber
2 x  | Buche | 8 | Beech | Timber
 | Buche | 46 | Beech | Timber
 | Buche | 47 | Beech | Timber
 | Buche | 48 | Beech | Timber
 | Buche | 49 | Beech | Timber
 | Buche | 50 | Beech | Timber
6 x  | Buche | 1 | Beech | Timber
2 x  | S235JR | 66 | S235JR | Steel
 | S235JR | 118 | S235JR | Steel
 | Buche | 59 | Beech | Timber
 | S235JR | 115 | S235JR | Steel
2 x  | S235JR | 74 | S235JR | Steel
 | S235JR | 114 | S235JR | Steel
 | S235JR | 105 | S235JR | Steel
 | S235JR | 106 | S235JR | Steel
 | S235JR | 97 | S235JR | Steel
 | S235JR | 98 | S235JR | Steel
 | Buche | 12 | Beech | Timber
 | S235JR | 99 | S235JR | Steel
 | Buche | 13 | Beech | Timber
 | S235JR | 96 | S235JR | Steel
 | S235JR | 95 | S235JR | Steel
 | S235JR | 104 | S235JR | Steel
 | S235JR | 103 | S235JR | Steel
 | S235JR | 113 | S235JR | Steel
 | S235JR | 112 | S235JR | Steel
 | Buche | 14 | Beech | Timber
 | Buche | 15 | Beech | Timber
 | Buche | 16 | Beech | Timber
 | Buche | 11 | Beech | Timber
3 x  | S235JR 10 mm | 122 | S235JR | Steel
12 x  | S235JR 10 mm | 119 | S235JR | Steel
3 x  | S235JR 10 mm | 121 | S235JR | Steel
26 x  | S235JR 15 mm | 128 | S235JR | Steel
49 x  | S235JR 15 mm | 131 | S235JR | Steel
21 x  | S235JR 15 mm | 132 | S235JR | Steel
3 x  | S235JR 15 mm | 136 | S235JR | Steel
23 x  | S235JR 15 mm | 129 | S235JR | Steel
6 x  | S235JR 15 mm | 135 | S235JR | Steel
20 x  | S235JR 15 mm | 133 | S235JR | Steel
 | S235JR 15 mm | 130 | S235JR | Steel
3 x  | S235JR 10 mm | 127 | S235JR | Steel
3 x  | S235JR 10 mm | 123 | S235JR | Steel
3 x  | S235JR 10 mm | 120 | S235JR | Steel
3 x  | S235JR 10 mm | 125 | S235JR | Steel

# IfcFastener: Weld (907)
In: Default Storey
AISC_EM11_Pset_Weld - Type1: Kehlnaht; a: 0 mm; l: 0 mm; s: 3 mm; WeldDescription: Weld; FieldWeld: no

# IfcMechanicalFastener: - (199)
In: Default Storey
Name | NominalDiameter (mm) | NominalLength (mm) | SequentialOrder | BoltStandard | BoltType | BoltGrade | BoltDiameter (mm) | BoltLength (mm) | BoltFieldAssembled
50 x  | 12 | 120 | Edelstahl A4
99 x  | 8 | 60 | Edelstahl A2 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 8 | 60 | yes
50 x  | 12 | 65 | Edelstahl A2 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 12 | 65 | yes

# IfcMember: Gel?nder (22)
In: Default Storey
Description: FL50X10; Material: S235JR
Pset_MemberCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: beschichtet RAL 7016
Name | Reference = PieceMark | Span (mm)
Gel?nder | 110 | 1275.33
Gel?nder | 68 | 1274.68
Gel?nder | 109 | 959.605
Gel?nder | 108 | 1275.33
Gel?nder | 107 | 163.817
Gel?nder | 73 | 959.118
Gel?nder | 101 | 1274.68
Gel?nder | 100 | 163.735
Gel?nder | 72 | 959.507
Gel?nder | 75 | 1275.2
Gel?nder | 116 | 163.801
Gel?nder | 114 | 953.551
Gel?nder | 105 | 952.585
Gel?nder | 106 | 1092.42
Gel?nder | 97 | 954.135
Gel?nder | 98 | 1088.24
Gel?nder | 96 | 1275.98
Gel?nder | 95 | 318.861
Gel?nder | 104 | 1285.82
Gel?nder | 103 | 318.351
Gel?nder | 113 | 1275.2
Gel?nder | 112 | 324.625

# IfcMember: Girder (12)
In: Default Storey
Description: RD40; Material: Buche
Pset_MemberCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: Beech; MaterialType: Timber
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: keine
Name | Reference = PieceMark | Span (mm)
Girder | 27 | 3122.23
Girder | 28 | 4093.55
Girder | 29 | 4085.53
Girder | 42 | 3168.44
Girder | 43 | 4126.87
Girder | 44 | 4115.61
Girder | 48 | 3142.23
Girder | 49 | 4113.55
Girder | 50 | 4105.53
Girder | 14 | 3071
Girder | 15 | 4018.13
Girder | 16 | 4029.52

# IfcPlate: Girder (179)
In: Default Storey
Description: -
Pset_PlateCommon - IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: beschichtet RAL 7016
Name | Material | Reference = PieceMark
3 x Girder | S235JR 10 mm | 122
12 x Girder | S235JR 10 mm | 119
3 x Girder | S235JR 10 mm | 121
26 x Girder | S235JR 15 mm | 128
49 x Girder | S235JR 15 mm | 131
21 x Girder | S235JR 15 mm | 132
3 x Girder | S235JR 15 mm | 136
23 x Girder | S235JR 15 mm | 129
6 x Girder | S235JR 15 mm | 135
20 x Girder | S235JR 15 mm | 133
Girder | S235JR 15 mm | 130
3 x Girder | S235JR 10 mm | 127
3 x Girder | S235JR 10 mm | 123
3 x Girder | S235JR 10 mm | 120
3 x Girder | S235JR 10 mm | 125
