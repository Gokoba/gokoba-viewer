Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[SteelFabricationView]
File name: Treppengel?nder f?r Mercedes-Benz_em11.ifc
Time: 2026-07-12T18:14:47
Organization: Alpha 2 Mercedes-Benz
Written by: IFC Toolkit 2.0.26.0
Made in: Advance Steel 2024

# IfcBuildingStorey, Default Storey
In: Struktur 1
Elevation: 0 mm

# IfcBeam: Hand_Rail (5)
In: Default Storey
Description: RO42.4x3; Material: 1.4301
Pset_BeamCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: 1.4301; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: geschliffen K240
Name | Reference = PieceMark | Span (mm)
Hand_Rail | 68 | 441.4
Hand_Rail | 70 | 436.4
Hand_Rail | 72 | 437.4
Hand_Rail | 74 | 1800.95
Hand_Rail | 69 | 2241

# IfcColumn: Gel?nder (36)
In: Default Storey
Description: FL50X10; Material: S235JR
Pset_ColumnCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Pulverbeschichtet RAL 9011
Name | Reference = PieceMark
3 x Gel?nder | 30
6 x Gel?nder | 28
Gel?nder | 41
Gel?nder | 45
Gel?nder | 34
7 x Gel?nder | 27
Gel?nder | 42
Gel?nder | 40
Gel?nder | 39
Gel?nder | 33
Gel?nder | 32
4 x Gel?nder | 29
Gel?nder | 37
Gel?nder | 36
Gel?nder | 44
Gel?nder | 43
Gel?nder | 35
Gel?nder | 38
2 x Gel?nder | 31

# IfcColumn: Girder (2)
In: Default Storey
Description: FL50X10; Material: S235JR
Pset_ColumnCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Pulverbeschichtet RAL 9011
Name | Reference = PieceMark
Girder | 25
Girder | 24

# IfcDiscreteAccessory: - (358)
In: Default Storey
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material | PieceMark | MaterialID | SequentialOrder
21 x - | FL50X10 | S235JR | 104 | S235JR | Pulverbeschichtet RAL 9011
22 x - | RD16 | 1.4301 | 157 | 1.4301 | geschliffen K240
14 x - | FL50X10 | S235JR | 106 | S235JR | Pulverbeschichtet RAL 9011
15 x - | RD16 | 1.4301 | 158 | 1.4301 | geschliffen K240
8 x - | RD12 | S235JR | 108 | S235JR | Pulverbeschichtet RAL 9011
56 x - | RD12 | S235JR | 102 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 121 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 120 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 122 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 112 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 126 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 115 | S235JR | Pulverbeschichtet RAL 9011
12 x - | RD12 | S235JR | 107 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 111 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 110 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 117 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 127 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 119 | S235JR | Pulverbeschichtet RAL 9011
24 x - | RD12 | S235JR | 103 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 129 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 118 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 124 | S235JR | Pulverbeschichtet RAL 9011
16 x - | RD12 | S235JR | 105 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 109 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 113 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 123 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 116 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 128 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 114 | S235JR | Pulverbeschichtet RAL 9011
4 x - | RD12 | S235JR | 125 | S235JR | Pulverbeschichtet RAL 9011
- | FL50X10 | S235JR | 130 | S235JR | Pulverbeschichtet RAL 9011
- | RO42.4x3 | 1.4301 | 171 | 1.4301 | geschliffen K240
- | RO42.4x3 | 1.4301 | 159 | 1.4301 | geschliffen K240
- | RO42.4x3 | 1.4301 | 168 | 1.4301 | geschliffen K240
- | RO42.4x3 | 1.4301 | 160 | 1.4301 | geschliffen K240
- | RO42.4x3 | 1.4301 | 161 | 1.4301 | geschliffen K240
- | RO42.4x3 | 1.4301 | 163 | 1.4301 | geschliffen K240
- | RO42.4x3 | 1.4301 | 174 | 1.4301 | geschliffen K240
- | RO42.4x3 | 1.4301 | 164 | 1.4301 | geschliffen K240
- | RO42.4x3 | 1.4301 | 165 | 1.4301 | geschliffen K240
33 x - | - | S235JR 16 mm | 100 | S235JR | Pulverbeschichtet RAL 9011
37 x - | - | 1.4301 16 mm | 176 | 1.4301 | geschliffen K240
4 x - | - | S235JR 16 mm | 101 | S235JR | Pulverbeschichtet RAL 9011
- | - | S235JR 10 mm | 180 | S235JR | Pulverbeschichtet RAL 9011
- | - | S235JR 10 mm | 181 | S235JR | Pulverbeschichtet RAL 9011

# IfcElementAssembly: Steel Assembly (58)
In: Default Storey
AssemblyPlace: FACTORY
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Material | PieceMark | MaterialID
3 x  | S235JR | 30 | S235JR
6 x  | S235JR | 28 | S235JR
 | S235JR | 41 | S235JR
 | S235JR | 45 | S235JR
 | S235JR | 34 | S235JR
7 x  | S235JR | 27 | S235JR
 | S235JR | 42 | S235JR
 | S235JR | 40 | S235JR
 | S235JR | 39 | S235JR
 | S235JR | 33 | S235JR
 | S235JR | 32 | S235JR
 | S235JR | 25 | S235JR
4 x  | S235JR | 29 | S235JR
 | S235JR | 37 | S235JR
 | S235JR | 36 | S235JR
 | S235JR | 44 | S235JR
 | S235JR | 43 | S235JR
 | S235JR | 35 | S235JR
 | 1.4301 | 68 | 1.4301
 | 1.4301 | 70 | 1.4301
 | 1.4301 | 72 | 1.4301
 | 1.4301 | 74 | 1.4301
 | S235JR | 38 | S235JR
2 x  | S235JR | 31 | S235JR
 | S235JR | 24 | S235JR
 | 1.4301 | 73 | 1.4301
 | 1.4301 | 69 | 1.4301
 | 1.4301 | 71 | 1.4301
 | 1.4301 | 67 | 1.4301
 | S235JR 10 mm | 12 | S235JR
 | S235JR 10 mm | 10 | S235JR
 | S235JR 10 mm | 1 | S235JR
 | S235JR 10 mm | 7 | S235JR
 | S235JR 10 mm | 3 | S235JR
 | S235JR 10 mm | 2 | S235JR
 | S235JR 10 mm | 5 | S235JR
 | S235JR 10 mm | 4 | S235JR
 | S235JR 10 mm | 6 | S235JR
 | S235JR 10 mm | 85 | S235JR
 | S235JR 10 mm | 8 | S235JR
 | S235JR 10 mm | 11 | S235JR

# IfcFastener: Weld (457)
In: Default Storey
AISC_EM11_Pset_Weld - Type1: Kehlnaht; a: 0 mm; l: 0 mm; s: 3 mm; WeldDescription: Weld; FieldWeld: no

# IfcMechanicalFastener: - (74)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: EN ISO 10642; BoltType: DIN 7991; BoltGrade: A2-70; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Edelstahl A2

# IfcMember: Hand_Rail (3)
In: Default Storey
Description: RO42.4x3; Material: 1.4301
Pset_MemberCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: 1.4301; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: geschliffen K240
Name | Reference = PieceMark | Span (mm)
Hand_Rail | 73 | 3010.69
Hand_Rail | 71 | 5007.04
Hand_Rail | 67 | 5569.31

# IfcPlate: - (12)
In: Default Storey
Description: -; Material: S235JR 10 mm
Pset_PlateCommon - IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Pulverbeschichtet RAL 9011
Name | Reference = PieceMark
- | 12
- | 10
- | 1
- | 7
- | 3
- | 2
- | 5
- | 4
- | 6
- | 85
- | 8
- | 11
