Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[SteelFabricationView]
File name: Einzelbalkon mit Zugangstreppe Bonn_em11.ifc
Time: 2026-07-12T21:39:41
Organization: Liegenschaft BN, Vinzenzstr. 31, 53332 Bornheim
Written by: IFC Toolkit 2.0.26.0
Made in: Advance Steel 2024

# IfcBuildingStorey, Default Storey
In: Struktur 1
Elevation: 0 mm

# IfcBeam: - (100)
In: Default Storey
Pset_BeamCommon - Reference: nicht definiert; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material | Span (mm) | MaterialID | MaterialType | SequentialOrder
- | Hutprofil 100x5 | S355JR | 2609 | S355JR | Steel | feuerverzinkt
- | Q100X4 | S235JR | 2730 | S235JR | Steel | feuerverzinkt
- | Rinnenprofil 130x5 | S235JR | 2920 | S235JR | Steel | feuerverzinkt
19 x - | FL80X6 | S235JR | 158 | S235JR | Steel | feuerverzinkt
9 x - | FL75X6 | S235JR | 1340 | S235JR | Steel | feuerverzinkt
16 x - | FL40X5 | S235JR | 204 | S235JR | Steel | feuerverzinkt
- | L60X40X5 | S235JR | 1340 | S235JR | Steel | feuerverzinkt
2 x - | C-Profil 217x30x4 | S235JR | 141.291 | S235JR | Steel | feuerverzinkt
- | R50X30X3 | S235JR | 134.58 | S235JR | Steel | feuerverzinkt
- | R30X20X2 | S235JR | 94.9124 | S235JR | Steel | feuerverzinkt
6 x - | Gummistreifen 60x3 | Gummi | 200 | Rubber | Others | feuerverzinkt
6 x - | L 200x100x10 | Alu | 60 | AL | Others | feuerverzinkt
3 x - | RHS80X60X4 | S235JR | 2937 | S235JR | Steel | feuerverzinkt
9 x - | FL40X5 | S235JR | 1340 | S235JR | Steel | feuerverzinkt
2 x - | FL40X5 | S235JR | 54 | S235JR | Steel | feuerverzinkt
8 x - |  | S235JR | 1340 | S235JR | Steel | keine
- | RHS?42.4x2.6 | S235JR | 134.596 | S235JR | Steel | feuerverzinkt
3 x - | R30X20X2 | S235JR | 876 | S235JR | Steel | feuerverzinkt
- | R50X30X3 | S235JR | 2820 | S235JR | Steel | feuerverzinkt
4 x - | G 200x5 (Typ III) | S355JR | 2940 | S355JR | Steel | feuerverzinkt
- | R50X30X3 | S235JR | 3139.58 | S235JR | Steel | feuerverzinkt
- | R30X20X2 | S235JR | 196.912 | S235JR | Steel | feuerverzinkt
3 x - | R30X20X2 | S235JR | 912 | S235JR | Steel | feuerverzinkt

# IfcBeam: Girder (8)
In: Default Storey
Material: S235JR
Pset_BeamCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Description | Reference = PieceMark | Span (mm)
Girder | RO82.5x5 (Mannesmann) | 1 | 220
2 x Girder | RO70x5 (Mannesmann) | 7 | 160
Girder | RO82.5x5 (Mannesmann) | 6 | 220
2 x Girder | RO70x5 (Mannesmann) | 8 | 174.999
2 x Girder | RO82.5x5 (Mannesmann) | 3 | 220

# IfcColumn: - (100)
In: Default Storey
Pset_ColumnCommon - Reference: nicht definiert; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Description | Material | MaterialID
6 x - | Q100X4 | S235JR | S235JR
- | RO50x2.5 | A500 GR.C | ASTMA500GRC
6 x - | Q90X4 | S235JR | S235JR
2 x - | C-Profil 217x30x4 | S235JR | S235JR
69 x - | RD12 | S235JR | S235JR
15 x - | R40X30X3 | S235JR | S235JR
- | RHS?48.3x2 | S235JR | S235JR

# IfcDiscreteAccessory: - (13)
In: Default Storey
Description: -
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: keine
Name | Material | PieceMark | MaterialID
2 x - | S355JR 15 mm | 409 | S355JR
- | S355JR 15 mm | 401 | S355JR
4 x - | S355JR 15 mm | 408 | S355JR
- | S235JR 10 mm | 400 | S235JR
- | S355JR 15 mm | 406 | S355JR
2 x - | S355JR 15 mm | 410 | S355JR
2 x - | S355JR 15 mm | 405 | S355JR

# IfcElementAssembly: Steel Assembly (12)
In: Default Storey
AssemblyPlace: FACTORY
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Material | PieceMark | MaterialID | MaterialType
 | S235JR | 1 | S235JR | Steel
2 x  | S235JR | 7 | S235JR | Steel
 | S235JR | 6 | S235JR | Steel
2 x  | S235JR | 8 | S235JR | Steel
2 x  | S235JR | 3 | S235JR | Steel
 | Thermostop 6 mm | 9
 | Thermostop 6 mm | 13
2 x  | Thermostop 6 mm | 12

# IfcFastener: Weld (277)
In: Default Storey
AISC_EM11_Pset_Weld - Type1: Kehlnaht; a: 0 mm; l: 0 mm; s: 3 mm; WeldDescription: Weld; FieldWeld: no

# IfcMechanicalFastener: - (94)
In: Default Storey
Name | NominalDiameter (mm) | NominalLength (mm) | BoltStandard | BoltType | BoltGrade | BoltDiameter (mm) | BoltLength (mm) | BoltFieldAssembled | SequentialOrder
6 x  | 8 | 20 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 8 | 20 | yes | Edelstahl A2
24 x  | 6 | 40 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 6 | 40 | yes | Edelstahl A2
2 x  | 12 | 130 |  |  |  |  |  |  | Edelstahl A4
4 x  | 12 | 120 |  |  |  |  |  |  | Edelstahl A4
31 x  | 12 | 40 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 12 | 40 | yes | Edelstahl A2
17 x  | 12 | 70 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 12 | 70 | yes | Edelstahl A2
 | 8 | 55 | ISO 4017 | DIN 7991 | A2-70 | 8 | 55 | yes | Edelstahl A2
2 x  | 16 | 40 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | 16 | 40 | yes | Feuerverzinkt
2 x  | 16 | 140 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 16 | 140 | yes | Edelstahl A2
 | 12 | 80 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 12 | 80 | yes | Edelstahl A2
4 x  | 12 | 65 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | 12 | 65 | yes | Edelstahl A2

# IfcMember: - (32)
In: Default Storey
Pset_MemberCommon - Reference: nicht definiert; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Description | Material | Span (mm) | MaterialID | MaterialType
2 x - | Q100X4 | S235JR | 905.457 | S235JR | Steel
4 x - | Q60X3 | S235JR | 794.996 | S235JR | Steel
2 x - | FL20X8 | Alu | 954.996 | AL | Others
- | Q50X4 | S235JR | 148.495 | S235JR | Steel
6 x - | Abdeckleiste f?r Dachbelag 50x5 | S235JR | 954.996 | S235JR | Steel
6 x - | Weichgummistreifen f?r Dachbelag 50x3 | S235JR | 904.996 | S235JR | Steel
2 x - | C-Profil 217x30x4 | S235JR | 2564.55 | S235JR | Steel
2 x - | R50X30X3 | S235JR | 2621.54 | S235JR | Steel
4 x - | R30X20X2 | S235JR | 936.896 | S235JR | Steel
2 x - | R30X20X2 | S235JR | 588.382 | S235JR | Steel
- | RHS?42.4x2.6 | S235JR | 2621.52 | S235JR | Steel

# IfcPlate: - (60)
In: Default Storey
Description: -
Pset_PlateCommon - IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Material | Reference = PieceMark | MainPieceTag | SequentialOrder | MaterialID | MaterialType
11 x - | Mineralit 35 mm | nicht definiert | no | keine
8 x - | S235JR 6 mm | nicht definiert | no | keine | S235JR | Steel
8 x - | S235JR 10 mm | nicht definiert | no | keine | S235JR | Steel
5 x - | Glas 8.76 mm | nicht definiert | no | keine | Glass | Others
22 x - | S235JR 5 mm | nicht definiert | no | keine | S235JR | Steel
- | Alu 5 mm | nicht definiert | no | roh | AL | Others
- | Thermostop 6 mm | 9 | yes | keine
- | Thermostop 6 mm | 13 | yes | keine
2 x - | Thermostop 6 mm | 12 | yes | keine
- | S235JR 3 mm | nicht definiert | no | keine | S235JR | Steel
