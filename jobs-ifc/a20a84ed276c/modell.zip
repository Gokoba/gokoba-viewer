Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[SteelFabricationView]
File name: Modell J?ttemann_Hermannstr.1a, Frankfurt_em11.ifc
Time: 2026-07-18T19:59:15
Organization: J?ttemann, Schlo?str. 94, 60486 Frankfurt
Written by: IFC Toolkit 2.0.26.0
Made in: Advance Steel 2024

# IfcBuildingStorey, Default Storey
In: Struktur 1
Elevation: 0 mm

# IfcBeam: - (160)
In: Default Storey
Pset_BeamCommon - Reference: nicht definiert; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material | Span (mm) | MaterialID | MaterialType | SequentialOrder
4 x - | R50X30X3 | S235JR | 324.999 | S235JR | Steel | feuerverzinkt
4 x - | R30X20X2 | S235JR | 274.999 | S235JR | Steel | feuerverzinkt
4 x - | R30X20X2 | S235JR | 294.997 | S235JR | Steel | feuerverzinkt
8 x - | R30X20X2 | S235JR | 94.9986 | S235JR | Steel | feuerverzinkt
16 x - | RHS80X60X4 | S235JR | 1119 | S235JR | Steel | feuerverzinkt
20 x - | RHS80X60X4 | S235JR | 1092 | S235JR | Steel | feuerverzinkt
36 x - |  | Alu | 960 | AL | Others | vorbeschichtet RAL 9016
8 x - | G 230x4 (Typ II) | S355JR | 3262 | S355JR | Steel | feuerverzinkt
8 x - | G 230x4 (Typ II) | S355JR | 1122 | S355JR | Steel | feuerverzinkt
4 x - | R50X30X3 | S235JR | 1180 | S235JR | Steel | feuerverzinkt
24 x - | R30X20X2 | S235JR | 890 | S235JR | Steel | feuerverzinkt
4 x - | R50X30X3 | S235JR | 2830 | S235JR | Steel | feuerverzinkt
8 x - | R30X20X2 | S235JR | 990 | S235JR | Steel | feuerverzinkt
12 x - | RO82.5x5 (Mannesmann) | S235JR | 200 | S235JR | Steel | keine

# IfcBeam: Gel?nder
In: Default Storey
Description: Q100X4; Material: S235JR
Pset_BeamCommon - Span: 3270 mm; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcColumn: - (154)
In: Default Storey
Pset_ColumnCommon - Reference: nicht definiert; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material | MaterialID | SequentialOrder
108 x - | RD12 | S235JR | S235JR | feuerverzinkt
4 x - | R30X20X2 | S235JR | S235JR | feuerverzinkt
4 x - |  | S235JR | S235JR | keine
9 x - | Q100X4 | S235JR | S235JR | feuerverzinkt
24 x - | R40X30X3 | S235JR | S235JR | feuerverzinkt
5 x - | RO50x2.5 | A500 GR.C | ASTMA500GRC | feuerverzinkt

# IfcDiscreteAccessory: - (11)
In: Default Storey
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material | MaterialID | SequentialOrder
2 x - | Q100X4 | S235JR | S235JR | feuerverzinkt
- | Rinnenprofil 130x5 | S355JR | S355JR | feuerverzinkt
4 x - | Q60X3 | S235JR | S235JR | feuerverzinkt
4 x - | - | S235JR 5 mm | S235JR | keine

# IfcElementAssembly: Steel Assembly (20)
In: Default Storey
AssemblyPlace: FACTORY
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Material | MaterialID | MaterialType
 | S235JR | S235JR | Steel
8 x  | Alu | AL | Others
6 x  | Gummi | Rubber | Others
5 x  | Glas 8.76 mm | Glass | Others

# IfcFastener: Weld (317)
In: Default Storey
AISC_EM11_Pset_Weld - Type1: Kehlnaht; a: 0 mm; l: 0 mm; s: 3 mm; WeldDescription: Weld; FieldWeld: no

# IfcMechanicalFastener: - (61)
In: Default Storey
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltFieldAssembled: yes
Name | NominalDiameter (mm) = BoltDiameter (mm) | NominalLength (mm) = BoltLength (mm) | BoltGrade | SequentialOrder
24 x  | 12 | 70 | A2-70 | Edelstahl A2
24 x  | 6 | 40 | A2-70 | Edelstahl A2
 | 8 | 20 | A2-70 | Edelstahl A2
8 x  | 12 | 60 | 8.8 | Feuerverzinkt
4 x  | 12 | 35 | 8.8 | Feuerverzinkt

# IfcMember: Girder (14)
In: Default Storey
Pset_MemberCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialType: Others
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: keine
Name | Description | Material | Span (mm) | MaterialID
2 x Girder | FL20X8 | Alu | 1165 | AL
6 x Girder | Weichgummistreifen f?r Dachbelag 50x3 | Gummi | 1115 | Rubber
6 x Girder | Abdeckleiste f?r Dachbelag 50x5 | Alu | 1165 | AL

# IfcPlate: - (157)
In: Default Storey
Description: -
Pset_PlateCommon - IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: keine
Name | Material | Reference = PieceMark | MainPieceTag
96 x - | BWS 40 mm | nicht definiert | no
15 x - | Thermostop 6 mm | nicht definiert | no
9 x - | S235JR 10 mm | nicht definiert | no | AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
28 x - | S235JR 20 mm | nicht definiert | no | AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
4 x - | S235JR 5 mm | nicht definiert | no | AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
5 x - | Glas 8.76 mm |  | yes | AISC_EM11_Pset_Material - MaterialID: Glass; MaterialType: Others
