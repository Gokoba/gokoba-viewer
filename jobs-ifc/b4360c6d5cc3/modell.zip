Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcDiscreteAccessory: Railing_Kneerail_Stair#1000 (2)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 455; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Stair#1001
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 427; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Stair#1002 (5)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Stair#1002 | 430
Railing_Kneerail_Stair#1002 | 427
Railing_Kneerail_Stair#1002 | 429
Railing_Kneerail_Stair#1002 | 428
Railing_Kneerail_Stair#1002 | 454

# IfcDiscreteAccessory: Railing_Kneerail_Stair#1003 (7)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Railing_Kneerail_Stair#1003 | 430
Railing_Kneerail_Stair#1003 | 427
2 x Railing_Kneerail_Stair#1003 | 429
2 x Railing_Kneerail_Stair#1003 | 428

# IfcDiscreteAccessory: Railing_Kneerail_Stair#1004 (3)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Stair#1004 | 457
Railing_Kneerail_Stair#1004 | 454
Railing_Kneerail_Stair#1004 | 456

# IfcDiscreteAccessory: Railing_Kneerail_Stair#1014
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 457; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Stair#1015 (4)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Stair#1015 | 430
Railing_Kneerail_Stair#1015 | 427
Railing_Kneerail_Stair#1015 | 429
Railing_Kneerail_Stair#1015 | 456

# IfcDiscreteAccessory: Railing_Kneerail_Stair#1017
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 428; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Stair#12
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 516; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Stair#13
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 433; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Stair#14 (2)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Stair#14 | 433
Railing_Kneerail_Stair#14 | 515

# IfcDiscreteAccessory: Railing_Kneerail_Stair#15 (6)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Stair#15 | 498
Railing_Kneerail_Stair#15 | 499
Railing_Kneerail_Stair#15 | 525
Railing_Kneerail_Stair#15 | 451
2 x Railing_Kneerail_Stair#15 | 463

# IfcDiscreteAccessory: Railing_Kneerail_Stair#16 (5)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Railing_Kneerail_Stair#16 | 434
Railing_Kneerail_Stair#16 | 459
Railing_Kneerail_Stair#16 | 451
Railing_Kneerail_Stair#16 | 458

# IfcDiscreteAccessory: Railing_Kneerail_Stair#17 (5)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
4 x Railing_Kneerail_Stair#17 | 443
Railing_Kneerail_Stair#17 | 524

# IfcDiscreteAccessory: Railing_Kneerail_Stair#2 (18)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
4 x Railing_Kneerail_Stair#2 | 437
Railing_Kneerail_Stair#2 | 487
Railing_Kneerail_Stair#2 | 496
Railing_Kneerail_Stair#2 | 433
Railing_Kneerail_Stair#2 | 494
2 x Railing_Kneerail_Stair#2 | 464
Railing_Kneerail_Stair#2 | 500
Railing_Kneerail_Stair#2 | 501
Railing_Kneerail_Stair#2 | 460
Railing_Kneerail_Stair#2 | 461
Railing_Kneerail_Stair#2 | 479
Railing_Kneerail_Stair#2 | 481
Railing_Kneerail_Stair#2 | 480
Railing_Kneerail_Stair#2 | 488

# IfcDiscreteAccessory: Railing_Kneerail_Stair#3 (17)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Railing_Kneerail_Stair#3 | 434
Railing_Kneerail_Stair#3 | 459
Railing_Kneerail_Stair#3 | 489
Railing_Kneerail_Stair#3 | 520
Railing_Kneerail_Stair#3 | 451
Railing_Kneerail_Stair#3 | 483
Railing_Kneerail_Stair#3 | 485
Railing_Kneerail_Stair#3 | 484
Railing_Kneerail_Stair#3 | 486
Railing_Kneerail_Stair#3 | 460
Railing_Kneerail_Stair#3 | 461
3 x Railing_Kneerail_Stair#3 | 452
Railing_Kneerail_Stair#3 | 503
Railing_Kneerail_Stair#3 | 458

# IfcDiscreteAccessory: Railing_Kneerail_Stair#4 (8)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
4 x Railing_Kneerail_Stair#4 | 438
Railing_Kneerail_Stair#4 | 491
Railing_Kneerail_Stair#4 | 492
Railing_Kneerail_Stair#4 | 512
Railing_Kneerail_Stair#4 | 513

# IfcDiscreteAccessory: Railing_Picket_Landing#0 (15)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#1 (8)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#12 (4)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
3 x Railing_Picket_Landing#12 | 453
Railing_Picket_Landing#12 | 541

# IfcDiscreteAccessory: Railing_Picket_Landing#13 (4)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#14 (4)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#15 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#16 (8)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
4 x Railing_Picket_Landing#16 | 449
2 x Railing_Picket_Landing#16 | 325
Railing_Picket_Landing#16 | 543
Railing_Picket_Landing#16 | 542

# IfcDiscreteAccessory: Railing_Picket_Landing#17 (8)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#18 (8)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#19 (8)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#2 (8)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#20 (9)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
8 x Railing_Picket_Landing#20 | 325
Railing_Picket_Landing#20 | 539

# IfcDiscreteAccessory: Railing_Picket_Landing#21 (7)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#22 (7)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#23 (7)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#24 (7)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#25 (7)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#26 (7)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#27 (8)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#28 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#29 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#30 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#31 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#32 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#33 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#34 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#35 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#36 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#37 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#38 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#39 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#40 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#41 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#42 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#43 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#44 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#45 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#46 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#47 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#48 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#49 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#50 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#51 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#52 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#53 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#54 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#55 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#56 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#57 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#58 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#59 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#60 (4)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#61 (4)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#62 (4)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#70
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 426; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#71
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#72
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#73
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#74
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#75
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#76 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
4 x Railing_Picket_Landing#76 | 450
Railing_Picket_Landing#76 | 325
Railing_Picket_Landing#76 | 536

# IfcDiscreteAccessory: Railing_Picket_Landing#77 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#78 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#79 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#80 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#81 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#82 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#83 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#84 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#85 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#86 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#87 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#88 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#89 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#90 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#91 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#92 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#93 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#94 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#95 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#96 (11)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Landing#97 (11)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 325; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#0 (36)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
8 x Railing_Picket_Stair#0 | 326
28 x Railing_Picket_Stair#0 | 325

# IfcDiscreteAccessory: Railing_Picket_Stair#1 (10)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
8 x Railing_Picket_Stair#1 | 326
Railing_Picket_Stair#1 | 537
Railing_Picket_Stair#1 | 538

# IfcDiscreteAccessory: Railing_Picket_Stair#10 (18)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#11 (18)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#12 (14)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#13 (14)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#14 (14)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#15 (13)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#16 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#17 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#18 (2)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#19 (2)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#2 (10)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#20
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#3 (18)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
4 x Railing_Picket_Stair#3 | 426
10 x Railing_Picket_Stair#3 | 326
4 x Railing_Picket_Stair#3 | 448

# IfcDiscreteAccessory: Railing_Picket_Stair#4 (18)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#5 (18)
In: Default Storey
Description: RD12; Material: S235JR
