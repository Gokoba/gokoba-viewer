Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[SteelFabricationView]
File name: Fluchttreppe an Verwaltungsgeb?ude_em11.ifc
Time: 2026-07-12T18:17:00
Organization: medius KLINIKEN gGmbH
Written by: IFC Toolkit 2.0.26.0
Made in: Advance Steel 2024

# IfcBuildingStorey, Default Storey
In: Struktur 1
Elevation: 0 mm

# IfcBeam: - (60)
In: Default Storey
Pset_BeamCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material = MaterialID | Reference = PieceMark | Span (mm) | MaterialType | SequentialOrder
2 x - | HEA240 | S235JR | 16 | 1440 | Steel | feuerverz. + pulverbesch.
- | HEA240 | S235JR | 32 | 1460 | Steel | feuerverz. + pulverbesch.
3 x - | IPE220 | S235JR | 7 | 2890 | Steel | feuerverz. + pulverbesch.
2 x - | IPE220 | S235JR | 20 | 3015 | Steel | feuerverz. + pulverbesch.
- | IPE220 | S235JR | 35 | 3015 | Steel | feuerverz. + pulverbesch.
2 x - | IPE220 | S235JR | 21 | 3015 | Steel | feuerverz. + pulverbesch.
- | IPE220 | S235JR | 36 | 3015 | Steel | feuerverz. + pulverbesch.
- | IPE220 | S235JR | 37 | 1265 | Steel | feuerverz. + pulverbesch.
- | IPE220 | S235JR | 34 | 1390 | Steel | feuerverz. + pulverbesch.
- | IPE220 | S235JR | 38 | 3015 | Steel | feuerverz. + pulverbesch.
2 x - | U220 | S235JR | 24 | 1974.1 | Steel | feuerverz. + pulverbesch.
3 x - | U220 | S235JR | 10 | 1274.1 | Steel | feuerverz. + pulverbesch.
4 x - | IPE160 | S235JR | 5 | 964.1 | Steel | feuerverz. + pulverbesch.
2 x - | IPE160 | S235JR | 18 | 884.1 | Steel | feuerverz. + pulverbesch.
2 x - | IPE160 | S235JR | 19 | 1264.1 | Steel | feuerverz. + pulverbesch.
4 x - | FL50X15 | S235JR | 4 | 1009 | Steel | feuerverz. + pulverbesch.
3 x - | FL50X15 | S235JR | 6 | 959 | Steel | feuerverz. + pulverbesch.
- | FL50X15 | S235JR | 31 | 909 | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 13 | 983.5 | Steel | feuerverz. + pulverbesch.
6 x - | FL50X15 | S235JR | 2 | 879 | Steel | feuerverz. + pulverbesch.
2 x - | HEA240 | S235JR | 17 | 2140 | Steel | feuerverz. + pulverbesch.
2 x - | IPE220 | S235JR | 22 | 3015 | Steel | feuerverz. + pulverbesch.
- | HEA240 | S235JR | 33 | 1980 | Steel | feuerverz. + pulverbesch.
- | IPE220 | S235JR | 39 | 3015 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 57 | 2110 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 67 | 1814.1 | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 11 | 879 | Steel | feuerverz. + pulverbesch.
2 x - | RO42.4X3.2 |  | 23 | 3070.2 |  | geschliffen K240
3 x - | RO42.4X3.2 |  | 9 | 2850.2 |  | geschliffen K240
- | RO42.4X3.2 |  | 53 | 1596.1 |  | geschliffen K240

# IfcColumn: - (36)
In: Default Storey
Material: S235JR
Pset_ColumnCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverz. + pulverbesch.
Name | Description | Reference = PieceMark
23 x - | R50X40X4 | 1
6 x - | R50X40X4 | 3
- | R50X40X4 | 40
3 x - | R50X40X4 | 8
- | FL35X15 | 26
- | FL35X15 | 27
- | FL35X15 | 25

# IfcDiscreteAccessory: - (660)
In: Default Storey
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material | PieceMark | MaterialID | MaterialType | SequentialOrder
62 x - | FL40x3 | S235JR | 101 | S235JR | Steel | feuerverzinkt
- | U220 | S235JR | 225 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 223 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 215 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 221 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | U220 | S235JR | 161 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 217 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 218 | S235JR | Steel | feuerverz. + pulverbesch.
- | IPE220 | S235JR | 195 | S235JR | Steel | feuerverz. + pulverbesch.
- | IPE220 | S235JR | 196 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 224 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 216 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 222 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 220 | S235JR | Steel | feuerverz. + pulverbesch.
5 x - | FL50X4 | S235JR | 110 | S235JR | Steel | feuerverzinkt
2 x - | FL35X15 | S235JR | 131 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL35X15 | S235JR | 132 | S235JR | Steel | feuerverz. + pulverbesch.
4 x - | FL35X15 | S235JR | 113 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL35X15 | S235JR | 130 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL35X15 | S235JR | 133 | S235JR | Steel | feuerverz. + pulverbesch.
4 x - | FL35X15 | S235JR | 114 | S235JR | Steel | feuerverz. + pulverbesch.
124 x - | FL35X15 | S235JR | 100 | S235JR | Steel | feuerverz. + pulverbesch.
42 x - | FL35X15 | S235JR | 102 | S235JR | Steel | feuerverz. + pulverbesch.
22 x - | FL35X15 | S235JR | 104 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL35X15 | S235JR | 162 | S235JR | Steel | feuerverz. + pulverbesch.
35 x - | FL35X15 | S235JR | 103 | S235JR | Steel | feuerverz. + pulverbesch.
4 x - | FL50X15 | S235JR | 115 | S235JR | Steel | feuerverz. + pulverbesch.
6 x - | FL50X15 | S235JR | 109 | S235JR | Steel | feuerverz. + pulverbesch.
3 x - | FL50X15 | S235JR | 120 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X15 | S235JR | 167 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 137 | S235JR | Steel | feuerverz. + pulverbesch.
6 x - | FL50X15 | S235JR | 108 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 139 | S235JR | Steel | feuerverz. + pulverbesch.
9 x - | FL35X15 | S235JR | 105 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 134 | S235JR | Steel | feuerverz. + pulverbesch.
8 x - | FL35X15 | S235JR | 106 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 136 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 135 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL35X15 | S235JR | 128 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 140 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL35X15 | S235JR | 163 | S235JR | Steel | feuerverz. + pulverbesch.
- | RO42.4X3.2 |  | 207 |  |  | geschliffen K240
- | RO42.4X3.2 |  | 206 |  |  | geschliffen K240
- | RO42.4X3.2 |  | 209 |  |  | geschliffen K240
- | U220 | S235JR | 214 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 211 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 212 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 210 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 213 | S235JR | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 219 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL50X4 | S235JR | 147 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 185 | S235JR | Steel | feuerverzinkt
4 x - | FL50X4 | S235JR | 116 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 148 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 156 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 149 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 150 | S235JR | Steel | feuerverzinkt
3 x - | FL50X4 | S235JR | 125 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 179 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 186 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 184 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 181 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 187 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 153 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 145 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 155 | S235JR | Steel | feuerverzinkt
4 x - | FL50X4 | S235JR | 117 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 173 | S235JR | Steel | feuerverzinkt
4 x - | FL50X4 | S235JR | 118 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 178 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 183 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 172 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 174 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 146 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 143 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 144 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 151 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 154 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 175 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 176 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 177 | S235JR | Steel | feuerverzinkt
2 x - | FL50X4 | S235JR | 152 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 182 | S235JR | Steel | feuerverzinkt
3 x - | FL50X4 | S235JR | 122 | S235JR | Steel | feuerverzinkt
3 x - | FL50X4 | S235JR | 121 | S235JR | Steel | feuerverzinkt
3 x - | FL50X4 | S235JR | 124 | S235JR | Steel | feuerverzinkt
3 x - | FL50X4 | S235JR | 123 | S235JR | Steel | feuerverzinkt
- | FL50X4 | S235JR | 180 | S235JR | Steel | feuerverzinkt
- | FL50X5 | S235JR | 190 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X5 | S235JR | 194 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X5 | S235JR | 192 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X5 | S235JR | 191 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X5 | S235JR | 189 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X5 | S235JR | 193 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X5 | S235JR | 188 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X15 | S235JR | 164 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 142 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL35X15 | S235JR | 127 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 138 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 141 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | FL35X15 | S235JR | 129 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X15 | S235JR | 165 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X15 | S235JR | 169 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X15 | S235JR | 170 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X15 | S235JR | 171 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X15 | S235JR | 168 | S235JR | Steel | feuerverz. + pulverbesch.
- | FL50X15 | S235JR | 166 | S235JR | Steel | feuerverz. + pulverbesch.
- | RO42.4X3.2 |  | 202 |  |  | geschliffen K240
- | RO42.4X3.2 |  | 198 |  |  | geschliffen K240
- | RO42.4X3.2 |  | 203 |  |  | geschliffen K240
- | RO42.4X3.2 |  | 204 |  |  | geschliffen K240
2 x - | RO42.4X3.2 |  | 157 |  |  | geschliffen K240
2 x - | RO42.4X3.2 |  | 160 |  |  | geschliffen K240
4 x - | RO42.4X3.2 |  | 119 |  |  | geschliffen K240
3 x - | RO42.4X3.2 |  | 126 |  |  | geschliffen K240
2 x - | RO42.4X3.2 |  | 159 |  |  | geschliffen K240
- | RO42.4X3.2 |  | 197 |  |  | geschliffen K240
- | RO42.4X3.2 |  | 208 |  |  | geschliffen K240
5 x - | RO42.4X3.2 |  | 112 |  |  | geschliffen K240
8 x - | RO42.4X3.2 |  | 107 |  |  | geschliffen K240
2 x - | RO42.4X3.2 |  | 158 |  |  | geschliffen K240
5 x - | RO42.4X3.2 |  | 111 |  |  | geschliffen K240
- | RO42.4X3.2 |  | 201 |  |  | geschliffen K240
- | RO42.4X3.2 |  | 199 |  |  | geschliffen K240
- | RO42.4X3.2 |  | 200 |  |  | geschliffen K240
- | RO42.4X3.2 |  | 205 |  |  | geschliffen K240
6 x - | - | S235JR 20 mm | 237 | S235JR | Steel | feuerverz. + pulverbesch.
18 x - | - | S235JR 15 mm | 230 | S235JR | Steel | feuerverz. + pulverbesch.
6 x - | - | S235JR 25 mm | 238 | S235JR | Steel | feuerverz. + pulverbesch.
6 x - | - | S235JR 25 mm | 240 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | - | S235JR 30 mm | 244 | S235JR | Steel | feuerverz. + pulverbesch.
6 x - | - | S235JR 25 mm | 241 | S235JR | Steel | feuerverz. + pulverbesch.
6 x - | - | S235JR 25 mm | 239 | S235JR | Steel | feuerverz. + pulverbesch.
6 x - | - | S235JR 10 mm | 235 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | - | S235JR 30 mm | 245 | S235JR | Steel | feuerverz. + pulverbesch.
16 x - | - | S235JR 10 mm | 231 | S235JR | Steel | feuerverz. + pulverbesch.
24 x - | - | S235JR 10 mm | 227 | S235JR | Steel | feuerverz. + pulverbesch.
- | - | S235JR 10 mm | 247 | S235JR | Steel | feuerverz. + pulverbesch.
6 x - | - | S235JR 10 mm | 234 | S235JR | Steel | feuerverz. + pulverbesch.
2 x - | - | S235JR 10 mm | 242 | S235JR | Steel | feuerverz. + pulverbesch.
23 x - | - | S235JR 5 mm | 229 | S235JR | Steel | feuerverz. + pulverbesch.
10 x - | - | S235JR 5 mm | 233 | S235JR | Steel | feuerverz. + pulverbesch.

# IfcDiscreteAccessory: Baseplate (2)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 243; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverz. + pulverbesch.

# IfcDiscreteAccessory: Grate_Step#2 (62)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 226; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#3 (62)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 226; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: LugPlate#1 (29)
In: Default Storey
Description: -; Material: S235JR 15 mm
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverz. + pulverbesch.
Name | PieceMark
23 x LugPlate#1 | 228
6 x LugPlate#1 | 236

# IfcDiscreteAccessory: Stiffener#0 (9)
In: Default Storey
Description: -; Material: S235JR 6 mm
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverz. + pulverbesch.
Name | PieceMark
8 x Stiffener#0 | 232
Stiffener#0 | 246

# IfcDiscreteAccessory: Stiffener#1 (9)
In: Default Storey
Description: -; Material: S235JR 6 mm
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverz. + pulverbesch.
Name | PieceMark
8 x Stiffener#1 | 232
Stiffener#1 | 246

# IfcElementAssembly: Steel Assembly (215)
In: Default Storey
AssemblyPlace: FACTORY
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Material | PieceMark | MaterialID | MaterialType
2 x  | S235JR | 16 | S235JR | Steel
 | S235JR | 32 | S235JR | Steel
3 x  | S235JR | 7 | S235JR | Steel
 | S235JR | 58 | S235JR | Steel
 | S235JR | 59 | S235JR | Steel
 | S235JR | 60 | S235JR | Steel
2 x  | S235JR | 20 | S235JR | Steel
 | S235JR | 35 | S235JR | Steel
2 x  | S235JR | 21 | S235JR | Steel
 | S235JR | 36 | S235JR | Steel
 | S235JR | 37 | S235JR | Steel
 | S235JR | 61 | S235JR | Steel
 | S235JR | 62 | S235JR | Steel
 | S235JR | 63 | S235JR | Steel
 | S235JR | 34 | S235JR | Steel
 | S235JR | 64 | S235JR | Steel
 | S235JR | 65 | S235JR | Steel
 | S235JR | 66 | S235JR | Steel
 | S235JR | 38 | S235JR | Steel
2 x  | S235JR | 24 | S235JR | Steel
3 x  | S235JR | 10 | S235JR | Steel
4 x  | S235JR | 5 | S235JR | Steel
2 x  | S235JR | 18 | S235JR | Steel
2 x  | S235JR | 19 | S235JR | Steel
23 x  | S235JR | 1 | S235JR | Steel
6 x  | S235JR | 3 | S235JR | Steel
 | S235JR | 40 | S235JR | Steel
3 x  | S235JR | 8 | S235JR | Steel
4 x  | S235JR | 4 | S235JR | Steel
3 x  | S235JR | 6 | S235JR | Steel
 | S235JR | 31 | S235JR | Steel
2 x  | S235JR | 13 | S235JR | Steel
6 x  | S235JR | 2 | S235JR | Steel
 | S235JR | 26 | S235JR | Steel
2 x  | S235JR | 14 | S235JR | Steel
2 x  | S235JR | 12 | S235JR | Steel
2 x  | S235JR | 15 | S235JR | Steel
 | S235JR | 27 | S235JR | Steel
2 x  | S235JR | 17 | S235JR | Steel
2 x  | S235JR | 22 | S235JR | Steel
 | S235JR | 33 | S235JR | Steel
 | S235JR | 39 | S235JR | Steel
 | S235JR | 57 | S235JR | Steel
 | S235JR | 54 | S235JR | Steel
 | S235JR | 55 | S235JR | Steel
 | S235JR | 56 | S235JR | Steel
 | S235JR | 67 | S235JR | Steel
 | S235JR | 28 | S235JR | Steel
2 x  | S235JR | 11 | S235JR | Steel
 | S235JR | 29 | S235JR | Steel
 | S235JR | 25 | S235JR | Steel
 | S235JR | 30 | S235JR | Steel
 |  | 43
 |  | 47
 |  | 42
 |  | 48
 |  | 41
 |  | 49
 |  | 46
 |  | 50
 |  | 45
 |  | 51
 |  | 44
 |  | 52
2 x  |  | 23
3 x  |  | 9
 |  | 53
53 x  | S235JR 40 mm | 68 | S235JR | Steel
9 x  | S235JR 40 mm | 70 | S235JR | Steel
2 x  | S235JR 60 mm | 71 | S235JR | Steel
2 x  | S235JR 60 mm | 72 | S235JR | Steel
 | S235JR 60 mm | 81 | S235JR | Steel
 | S235JR 60 mm | 82 | S235JR | Steel
2 x  | S235JR 60 mm | 73 | S235JR | Steel
2 x  | S235JR 60 mm | 74 | S235JR | Steel
2 x  | S235JR 60 mm | 75 | S235JR | Steel
 | S235JR 60 mm | 83 | S235JR | Steel
 | S235JR 60 mm | 84 | S235JR | Steel
 | S235JR 60 mm | 85 | S235JR | Steel
 | S235JR 60 mm | 86 | S235JR | Steel
 | S235JR 60 mm | 87 | S235JR | Steel
 | S235JR 60 mm | 88 | S235JR | Steel
 | S235JR 60 mm | 89 | S235JR | Steel
 | S235JR 60 mm | 76 | S235JR | Steel
 | S235JR 60 mm | 77 | S235JR | Steel
 | S235JR 60 mm | 78 | S235JR | Steel
 | S235JR 60 mm | 79 | S235JR | Steel
 | S235JR 60 mm | 80 | S235JR | Steel

# IfcFastener: Weld (1347)
In: Default Storey
AISC_EM11_Pset_Weld - a: 0 mm; l: 0 mm; WeldDescription: Weld; FieldWeld: no
Name | Type1 | s (mm)
96 x  | Kehlnaht | 4
24 x  | Kehlnaht | 7
1054 x  | Kehlnaht | 3
36 x  | Kehlnaht | 5
18 x  | Kehlnaht | 6
14 x  | HV | 9
83 x  | Doppel-Kehlnaht | 3
4 x  | HV | 12
18 x  | V | 4

# IfcMechanicalFastener: - (165)
In: Default Storey
AISC_EM11_Pset_Bolt - BoltFieldAssembled: yes
Name | NominalDiameter (mm) = BoltDiameter (mm) | NominalLength (mm) = BoltLength (mm) | BoltStandard | BoltType | BoltGrade | SequentialOrder
2 x  | 20 | 95 | DIN 6914 | 6914 | 10.9 | Feuerverzinkt
16 x  | 16 | 40 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | Feuerverzinkt
33 x  | 12 | 70 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | Feuerverzinkt
27 x  | 8 | 30 | ISO 4017 | DIN 933 (ISO 4017) | A2-70 | Edelstahl A4
36 x  | 20 | 50 | DIN 6914 | 6914 | 10.9 | Feuerverzinkt
18 x  | 12 | 45 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | Feuerverzinkt
26 x  | 10 | 90 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | Feuerverzinkt
7 x  | 10 | 75 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | Feuerverzinkt

# IfcMechanicalFastener: Anchor_Bolt#1 (2)
In: Default Storey
NominalDiameter: 16 mm; NominalLength: 150 mm
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt (300)
In: Default Storey
NominalDiameter: 12 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalLength (mm) = BoltLength (mm)
248 x  | 35
52 x  | 45

# IfcMechanicalFastener: Bolt#1 (29)
In: Default Storey
NominalDiameter: 16 mm; NominalLength: 50 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 16 mm; BoltLength: 50 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMember: - (33)
In: Default Storey
Pset_MemberCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material = MaterialID | Reference = PieceMark | Span (mm) | MaterialType | SequentialOrder
- | U220 | S235JR | 58 | 4183.51 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 59 | 4148.66 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 60 | 3109.63 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 61 | 3997.44 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 62 | 3810.51 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 63 | 3817.66 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 64 | 4183.51 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 65 | 4148.66 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 66 | 3109.63 | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 14 | 1176.12 | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 12 | 1167.53 | Steel | feuerverz. + pulverbesch.
2 x - | FL50X15 | S235JR | 15 | 1169.43 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 54 | 3997.44 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 55 | 3780.56 | Steel | feuerverz. + pulverbesch.
- | U220 | S235JR | 56 | 3787.05 | Steel | feuerverz. + pulverbesch.
- | FL50X15 | S235JR | 28 | 1169.43 | Steel | feuerverz. + pulverbesch.
- | FL50X15 | S235JR | 29 | 1167.53 | Steel | feuerverz. + pulverbesch.
- | FL50X15 | S235JR | 30 | 1070.39 | Steel | feuerverz. + pulverbesch.
- | RO42.4X3.2 |  | 43 | 3060.19 |  | geschliffen K240
- | RO42.4X3.2 |  | 47 | 3060.19 |  | geschliffen K240
- | RO42.4X3.2 |  | 42 | 4069.54 |  | geschliffen K240
- | RO42.4X3.2 |  | 48 | 4069.54 |  | geschliffen K240
- | RO42.4X3.2 |  | 41 | 4100.29 |  | geschliffen K240
- | RO42.4X3.2 |  | 49 | 4100.29 |  | geschliffen K240
- | RO42.4X3.2 |  | 46 | 3737.62 |  | geschliffen K240
- | RO42.4X3.2 |  | 50 | 3737.62 |  | geschliffen K240
- | RO42.4X3.2 |  | 45 | 3731.39 |  | geschliffen K240
- | RO42.4X3.2 |  | 51 | 3731.39 |  | geschliffen K240
- | RO42.4X3.2 |  | 44 | 4207.16 |  | geschliffen K240
- | RO42.4X3.2 |  | 52 | 4213.03 |  | geschliffen K240

# IfcPlate: Grate_Step#1 (62)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Reference = PieceMark
53 x Grate_Step#1 | 68
9 x Grate_Step#1 | 70

# IfcPlate: Grating (24)
In: Default Storey
Description: -; Material: S235JR 60 mm
Pset_PlateCommon - IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Reference = PieceMark
2 x Grating | 71
2 x Grating | 72
Grating | 81
Grating | 82
2 x Grating | 73
2 x Grating | 74
2 x Grating | 75
Grating | 83
Grating | 84
Grating | 85
Grating | 86
Grating | 87
Grating | 88
Grating | 89
Grating | 76
Grating | 77
Grating | 78
Grating | 79
Grating | 80
