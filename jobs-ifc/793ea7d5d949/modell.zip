Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[SteelFabricationView]
File name: Modell Treppe Ost Unterschlei?heim_em11.ifc
Time: 2026-07-28T09:38:45
Organization: Stadt Unterschlei?heim
Written by: IFC Toolkit 2.0.26.0
Made in: Advance Steel 2024

# IfcBuildingStorey, Default Storey
In: Struktur 1
Elevation: 0 mm

# IfcBeam: - (85)
In: Default Storey
Pset_BeamCommon - Reference: nicht definiert; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material = MaterialID | Span (mm) | SequentialOrder
- | U240 | S235JR | 1470 | feuerverzinkt
- | U240 | S235JR | 344.999 | feuerverzinkt
- | L40X4 | S235JR | 530.703 | keine
- | L40X4 | S235JR | 1665.7 | keine
- | FL40X8 | S235JR | 208.357 | feuerverzinkt
- | FL40X8 | S235JR | 257.791 | feuerverzinkt
- | RHS?30x2 | 1.4301 | 129.796 | geschliffen K240
- | RHS?30x2 | 1.4301 | 590.298 | geschliffen K240
- | U240 | S235JR | 1530 | feuerverzinkt
2 x - | FL40X8 | S235JR | 1367.5 | feuerverzinkt
- | U240 | S235JR | 3020 | feuerverzinkt
2 x - | FL40X8 | S235JR | 2975 | feuerverzinkt
- | RHS?30x2 | 1.4301 | 111.001 | geschliffen K240
- | RHS?30x2 | 1.4301 | 28.5 | geschliffen K240
- | FL50X6 | S235JR | 1348 | feuerverzinkt
- | RHS?30x2 | 1.4301 | 2698 | geschliffen K240
2 x - | RD20 | S235JR | 1218.6 | feuerverzinkt
2 x - | RD20 | S235JR | 1063.78 | feuerverzinkt
- | HEB220 | S235JR | 3000 | feuerverzinkt
- | HEB220 | S235JR | 1755 | feuerverzinkt
20 x - | Antrittskante Giro 70 mm | S235JR | 1194 | keine
- | FL40X8 | S235JR | 48.5661 | feuerverzinkt
2 x - | Antrittskante Giro 70 mm | S235JR | 1198 | keine
- | L40X4 | S235JR | 1511.3 | keine
- | L40X4 | S235JR | 173.296 | keine
- | FL40X8 | S235JR | 97.9995 | feuerverzinkt
2 x - | U240 | S235JR | 1474.71 | feuerverzinkt
- | RHS?30x2 | 1.4301 | 245.79 | geschliffen K240
- | RHS?30x2 | 1.4301 | 335.499 | geschliffen K240
- | T120 | S235JR | 1115 | feuerverzinkt
2 x - | U240 | S235JR | 214.999 | feuerverzinkt
2 x - | FL40X8 | S235JR | 192.499 | feuerverzinkt
2 x - | FL40X8 | S235JR | 201.499 | feuerverzinkt
2 x - | RHS?30x2 | 1.4301 | 234 | geschliffen K240
2 x - | FL40X8 | S235JR | 1358 | feuerverzinkt
2 x - | FL40X8 | S235JR | 418.797 | feuerverzinkt
2 x - | FL40X8 | S235JR | 1308.57 | feuerverzinkt
- | RHS?30x2 | 1.4301 | 1359 | geschliffen K240
- | RHS?30x2 | 1.4301 | 281.299 | geschliffen K240
- | FL40X8 | S235JR | 1071.59 | feuerverzinkt
2 x - | FL40X8 | S235JR | 404.202 | feuerverzinkt
- | FL40X8 | S235JR | 1022.16 | feuerverzinkt
- | RHS?30x2 | 1.4301 | 266.703 | geschliffen K240
- | RHS?30x2 | 1.4301 | 1029.09 | geschliffen K240
2 x - | FL40X8 | S235JR | 238.796 | feuerverzinkt
- | U240 | S235JR | 1654.71 | feuerverzinkt
- | U240 | S235JR | 529.707 | feuerverzinkt
- | FL40X8 | S235JR | 509.364 | feuerverzinkt
- | FL40X8 | S235JR | 558.797 | feuerverzinkt
- | L40X4 | S235JR | 566.299 | keine
- | L40X4 | S235JR | 1701.3 | keine

# IfcColumn: - (246)
In: Default Storey
Pset_ColumnCommon - Reference: nicht definiert; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material = MaterialID | SequentialOrder
205 x - | FL40X8 | S235JR | feuerverzinkt
2 x - | RHS?30x2 | 1.4301 | geschliffen K240
35 x - | RD8 | 1.4301 | geschliffen K240
2 x - | HEB220 | S235JR | feuerverzinkt
2 x - | U240 | S235JR | feuerverzinkt

# IfcFastener: Weld (470)
In: Default Storey
AISC_EM11_Pset_Weld - Type1: Kehlnaht; a: 0 mm; l: 0 mm; s: 3 mm; WeldDescription: Weld; FieldWeld: no

# IfcMechanicalFastener: - (216)
In: Default Storey
Name | NominalDiameter (mm) | NominalLength (mm) | BoltStandard | BoltType | BoltGrade | BoltDiameter (mm) | BoltLength (mm) | BoltFieldAssembled | SequentialOrder
101 x  | 12 | 45 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | 12 | 45 | yes | Edelstahl A2
13 x  | 16 | 45 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | 16 | 45 | yes | Edelstahl A2
2 x  | 16 | 170 |  |  |  |  |  |  | Edelstahl A4
80 x  | 12 | 35 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | 12 | 35 | yes | Edelstahl A2
4 x  | 20 | 70 | DIN 6914 | 6914 | 10.9 | 20 | 70 | yes | Feuerverzinkt
4 x  | 12 | 40 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | 12 | 40 | yes | Edelstahl A2
4 x  | 6 | 20 | ISO 4017 | DIN 7991 | A2-70 | 6 | 20 | yes | Edelstahl A2
6 x  | 16 | 55 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | 16 | 55 | yes | Edelstahl A2
2 x  | 12 | 130 |  |  |  |  |  |  | Edelstahl A4

# IfcMember: - (16)
In: Default Storey
Pset_MemberCommon - Reference: nicht definiert; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material = MaterialID | Span (mm) | SequentialOrder
2 x - | RHS?30x2 | 1.4301 | 3362.76 | geschliffen K240
2 x - | RHS?30x2 | 1.4301 | 3713.27 | geschliffen K240
4 x - | FL40X8 | S235JR | 3356.83 | feuerverzinkt
2 x - | U240 | S235JR | 3419.38 | feuerverzinkt
2 x - | FL40X8 | S235JR | 3775.11 | feuerverzinkt
2 x - | U240 | S235JR | 3772.95 | feuerverzinkt
2 x - | FL40X8 | S235JR | 3713.27 | feuerverzinkt

# IfcPlate: - (129)
In: Default Storey
Description: -
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Material | MaterialID | MaterialType | SequentialOrder
35 x - | S235JR 8 mm | S235JR | Steel | keine
14 x - | S235JR 20 mm | S235JR | Steel | feuerverzinkt
29 x - | S235JR 10 mm | S235JR | Steel | keine
4 x - | S235JR 5 mm | S235JR | Steel | keine
- | Thermostop 10 mm |  |  | keine
- | Thermostop 6 mm |  |  | keine
2 x - | S235JR 15 mm | S235JR | Steel | keine
2 x - | S235JR 30 mm | S235JR | Steel | feuerverzinkt
40 x - | S235JR 3 mm | S235JR | Steel | keine
- | S235JR 25 mm | S235JR | Steel | feuerverzinkt

# IfcPlate: Grating (25)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcPlate: Stiffener#0 (3)
In: Default Storey
Description: -; Material: S235JR 15 mm
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: keine

# IfcPlate: Stiffener#1 (13)
In: Default Storey
Description: -
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: keine
Name | Material
3 x Stiffener#1 | S235JR 15 mm
10 x Stiffener#1 | S235JR 10 mm
