Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[SteelFabricationView]
File name: Modellbereich Deckenger?st_em11.ifc
Time: 2026-07-14T21:49:37
Organization: Landeshauptstadt M?nchen
Written by: IFC Toolkit 2.0.26.0
Made in: Advance Steel 2024

# IfcBuildingStorey, Default Storey
In: Struktur 1
Elevation: 0 mm

# IfcBeam: Gel?nder (3)
In: Default Storey
Description: RO60.3X2.6; Material: S235JR
Pset_BeamCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + beschichtet [C1] RAL 9016
Name | Reference = PieceMark | Span (mm)
Gel?nder | 4 | 1630.15
Gel?nder | 3 | 1700
Gel?nder | 2 | 1630.15

# IfcBeam: Girder (6)
In: Default Storey
Description: RO60.3X2.6; Material: S235JR
Pset_BeamCommon - Reference: 1; Span: 1299 mm; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: 1; MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + beschichtet [C1] RAL 9016

# IfcDiscreteAccessory: - (52)
In: Default Storey
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + beschichtet [C1] RAL 9016
Name | Description | Material | PieceMark
3 x - | RO60.3X2.6 | S235JR | 105
2 x - | RO60.3X2.6 | S235JR | 106
4 x - | RO60.3X2.6 | S235JR | 104
4 x - | RO60.3X2.6 | S235JR | 101
- | RO60.3X2.6 | S235JR | 108
2 x - | RO60.3X2.6 | S235JR | 107
4 x - | RO60.3X2.6 | S235JR | 102
10 x - | RO60.3X2.6 | S235JR | 100
4 x - | RO60.3X2.6 | S235JR | 103
18 x - | - | S235JR 10 mm | 109

# IfcElementAssembly: Steel Assembly (27)
In: Default Storey
AssemblyPlace: FACTORY
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_DrawingNumber - DrawingNumber: 051_A0-Tr?ger
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Material | PieceMark
 | S235JR | 4
 | S235JR | 3
6 x  | S235JR | 1
 | S235JR | 2
18 x  | S235JR 10 mm | 5

# IfcFastener: Weld (142)
In: Default Storey
AISC_EM11_Pset_Weld - Type1: Kehlnaht; a: 0 mm; l: 0 mm; s: 3 mm; WeldDescription: Weld; FieldWeld: no

# IfcMechanicalFastener: - (12)
In: Default Storey
NominalDiameter: 6 mm; NominalLength: 20 mm
AISC_EM11_Pset_Bolt - BoltStandard: DIN 912; BoltType: 912; BoltGrade: A2-70; BoltDiameter: 6 mm; BoltLength: 20 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Edelstahl A2

# IfcPlate: - (18)
In: Default Storey
Description: -; Material: S235JR 10 mm
Pset_PlateCommon - Reference: 5; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: 5; MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + beschichtet [C1] RAL 9016
