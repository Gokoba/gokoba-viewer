Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcDiscreteAccessory: Railing_Picket_Stair#5 (18)
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#55
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#56
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#57
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#58
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#59
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#6 (18)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#60 (2)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Picket_Stair#60 | 326
Railing_Picket_Stair#60 | 540

# IfcDiscreteAccessory: Railing_Picket_Stair#61 (2)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#62 (2)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#63 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Railing_Picket_Stair#63 | 326
4 x Railing_Picket_Stair#63 | 447

# IfcDiscreteAccessory: Railing_Picket_Stair#64 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#65 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#66 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#67 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#68 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#69 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#7 (20)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#70 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#71 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#72 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#73 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#74 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#75 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#8 (18)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Picket_Stair#9 (18)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 326; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#0 (10)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#11
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#12 (6)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#13 (6)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#14 (5)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#2 (9)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#3 (10)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#4 (7)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#5 (6)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#6 (6)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#7 (6)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#8 (5)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Landing#9 (4)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 327; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Stair#0 (10)
In: Default Storey
Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Description | PieceMark
2 x Railing_Post_Stair#0 | FL60X10 | 465
8 x Railing_Post_Stair#0 | FL60X15 | 329

# IfcDiscreteAccessory: Railing_Post_Stair#1 (18)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 329; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Stair#10 (6)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 329; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Stair#11 (5)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 329; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Stair#2 (9)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 329; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Stair#8
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 329; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Post_Stair#9 (2)
In: Default Storey
Description: FL60X15; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 329; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Stiffener#0 (23)
In: Default Storey
Description: -; Material: S235JR 10 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 320; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Stiffener#1 (129)
In: Default Storey
Description: -; Material: S235JR 10 mm
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | PieceMark | SequentialOrder
82 x Stiffener#1 | 343 | feuerverzinkt
24 x Stiffener#1 | 301 | keine
23 x Stiffener#1 | 320 | feuerverzinkt

# IfcDiscreteAccessory: Stiffener#2 (24)
In: Default Storey
Description: -; Material: S235JR 10 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 301; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: keine

# IfcDiscreteAccessory: Stiffener#3 (24)
In: Default Storey
Description: -; Material: S235JR 10 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 301; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: keine

# IfcDiscreteAccessory: Stiffener#4 (24)
In: Default Storey
Description: -; Material: S235JR 10 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 301; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: keine

# IfcDiscreteAccessory: Stringer (2)
In: Default Storey
Description: U240; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Stringer | 392
Stringer | 393

# IfcDiscreteAccessory: Stringer#1 (12)
In: Default Storey
Description: U240; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Stringer#1 | 378
Stringer#1 | 376
Stringer#1 | 370
Stringer#1 | 382
Stringer#1 | 380
Stringer#1 | 372
Stringer#1 | 384
Stringer#1 | 374
Stringer#1 | 362
Stringer#1 | 368
Stringer#1 | 364
Stringer#1 | 366

# IfcDiscreteAccessory: Stringer#2 (12)
In: Default Storey
Description: U240; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Stringer#2 | 379
Stringer#2 | 377
Stringer#2 | 371
Stringer#2 | 383
Stringer#2 | 381
Stringer#2 | 373
Stringer#2 | 385
Stringer#2 | 375
Stringer#2 | 363
Stringer#2 | 369
Stringer#2 | 365
Stringer#2 | 367

# IfcDiscreteAccessory: TopLanding#1 (5)
In: Default Storey
Description: U100; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 350; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: TopLanding#3 (24)
In: Default Storey
Description: L40X4; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
11 x TopLanding#3 | 346
6 x TopLanding#3 | 348
5 x TopLanding#3 | 349
2 x TopLanding#3 | 359

# IfcElementAssembly: Steel Assembly (341)
In: Default Storey
AssemblyPlace: FACTORY
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Material | PieceMark
 | S235JR | 54
 | S235JR | 53
 | S235JR | 50
 | S235JR | 49
 | S235JR | 57
 | S235JR | 58
 | S235JR | 61
 | S235JR | 62
 | S235JR | 56
 | S235JR | 55
 | S235JR | 60
 | S235JR | 59
 | S235JR | 64
 | S235JR | 63
5 x  | S235JR | 34
 | S235JR | 20
 | S235JR | 39
 | S235JR | 40
11 x  | S235JR | 17
 | S235JR | 18
2 x  | S235JR | 22
2 x  | S235JR | 26
2 x  | S235JR | 24
2 x  | S235JR | 23
2 x  | S235JR | 25
2 x  | S235JR | 27
2 x  | S235JR | 28
2 x  | S235JR | 29
2 x  | S235JR | 30
2 x  | S235JR | 31
2 x  | S235JR | 32
2 x  | S235JR | 33
12 x  | S235JR | 21
 | S235JR | 52
 | S235JR | 51
 | S235JR | 78
 | S235JR | 80
 | S235JR | 77
 | S235JR | 79
 | S235JR | 76
5 x  | S235JR | 66
 | S235JR | 75
5 x  | S235JR | 65
 | S235JR | 46
 | S235JR | 45
 | S235JR | 74
 | S235JR | 73
 | S235JR | 72
 | S235JR | 71
 | S235JR | 69
 | S235JR | 70
 | S235JR | 42
 | S235JR | 41
 | S235JR | 68
 | S235JR | 67
 | S235JR | 81
 | S235JR | 83
 | S235JR | 85
 | S235JR | 87
 | S235JR | 89
 | S235JR | 91
 | S235JR | 82
 | S235JR | 84
 | S235JR | 86
 | S235JR | 88
 | S235JR | 90
 | S235JR | 43
 | S235JR | 44
 | S235JR | 92
 | S235JR | 48
 | S235JR | 47
 | S235JR | 93
5 x  | S235JR | 35
 | S235JR | 37
 | S235JR | 38
5 x  | S235JR | 36
 | S235JR | 19
 | S235JR | 2
 | S235JR | 1
 | S235JR | 3
 | S235JR | 4
 | S235JR | 5
 | S235JR | 6
 | S235JR | 7
 | S235JR | 8
 | S235JR | 9
 | S235JR | 10
 | S235JR | 11
 | S235JR | 12
 | S235JR | 13
 | S235JR | 14
 | S235JR | 15
 | S235JR | 16
8 x  | S235JR 12 mm | 117
82 x  | S235JR 40 mm | 94
48 x  | S235JR 15 mm | 112
12 x  | S235JR 10 mm | 116
2 x  | S235JR 40 mm | 103
 | S235JR 40 mm | 107
6 x  | S235JR 40 mm | 95
 | S235JR 40 mm | 108
5 x  | S235JR 40 mm | 96
4 x  | S235JR 40 mm | 98
5 x  | S235JR 40 mm | 97
 | S235JR 40 mm | 109
2 x  | S235JR 40 mm | 104
2 x  | S235JR 40 mm | 105
4 x  | S235JR 40 mm | 99
4 x  | S235JR 40 mm | 100
4 x  | S235JR 40 mm | 102
4 x  | S235JR 40 mm | 101

# IfcFastener: Weld (4021)
In: Default Storey
AISC_EM11_Pset_Weld - a: 0 mm; l: 0 mm; WeldDescription: Weld
Name | Type1 | s (mm) | FieldWeld
204 x  | Kehlnaht | 5 | no
12 x  | Kehlnaht | 8 | no
2593 x  | Kehlnaht | 3 | no
46 x  | Kehlnaht | 3 | yes
5 x  | Kehlnaht | 9 | no
441 x  | Kehlnaht | 4 | no
292 x  | Doppel-Kehlnaht | 3 | no
428 x  | Doppel-Kehlnaht | 4 | no

# IfcMechanicalFastener: - (145)
In: Default Storey
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalDiameter (mm) = BoltDiameter (mm) | NominalLength (mm) = BoltLength (mm)
60 x  | 8 | 30
10 x  | 12 | 40
3 x  | 12 | 45
48 x  | 16 | 65
24 x  | 16 | 55

# IfcMechanicalFastener: Anchor_Bolt (2)
In: Default Storey
NominalDiameter: 16 mm; NominalLength: 220 mm
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt (420)
In: Default Storey
NominalDiameter: 12 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalLength (mm) = BoltLength (mm)
328 x  | 35
92 x  | 45

# IfcMechanicalFastener: Bolt#1 (38)
In: Default Storey
AISC_EM11_Pset_Bolt - BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalDiameter (mm) = BoltDiameter (mm) | NominalLength (mm) = BoltLength (mm) | BoltStandard | BoltType | BoltGrade
 | 16 | 55 | DIN 6914 | 6914 | 10.9
24 x  | 16 | 45 | ISO 4017 | DIN 933 (ISO 4017) | 8.8
12 x  | 20 | 85 | DIN 6914 | 6914 | 10.9
 | 16 | 75 | DIN 6914 | 6914 | 10.9

# IfcMechanicalFastener: Bolt#2 (86)
In: Default Storey
AISC_EM11_Pset_Bolt - BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalDiameter (mm) = BoltDiameter (mm) | NominalLength (mm) = BoltLength (mm) | BoltStandard | BoltType | BoltGrade
 | 16 | 55 | DIN 6914 | 6914 | 10.9
72 x  | 16 | 45 | ISO 4017 | DIN 933 (ISO 4017) | 8.8
12 x  | 20 | 85 | DIN 6914 | 6914 | 10.9
 | 16 | 75 | DIN 6914 | 6914 | 10.9

# IfcMechanicalFastener: Bolt#3 (2)
In: Default Storey
NominalDiameter: 16 mm
AISC_EM11_Pset_Bolt - BoltStandard: DIN 6914; BoltType: 6914; BoltGrade: 10.9; BoltDiameter: 16 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalLength (mm) = BoltLength (mm)
 | 55
 | 75

# IfcMechanicalFastener: Bolt#4 (2)
In: Default Storey
NominalDiameter: 16 mm
AISC_EM11_Pset_Bolt - BoltStandard: DIN 6914; BoltType: 6914; BoltGrade: 10.9; BoltDiameter: 16 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalLength (mm) = BoltLength (mm)
 | 55
 | 75

# IfcMechanicalFastener: Bolt#5 (26)
In: Default Storey
NominalDiameter: 16 mm
AISC_EM11_Pset_Bolt - BoltDiameter: 16 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalLength (mm) = BoltLength (mm) | BoltStandard | BoltType | BoltGrade
 | 55 | DIN 6914 | 6914 | 10.9
24 x  | 45 | ISO 4017 | DIN 933 (ISO 4017) | 8.8
 | 75 | DIN 6914 | 6914 | 10.9

# IfcMechanicalFastener: Bolt#500 (18)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#501 (18)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#502 (18)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#503 (10)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#504 (7)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#505 (6)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#506 (6)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#507 (6)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#508 (6)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#509 (6)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#510 (6)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#511 (6)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#512 (6)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#513 (6)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#514 (5)
In: Default Storey
NominalDiameter: 12 mm; NominalLength: 55 mm
AISC_EM11_Pset_Bolt - BoltStandard: ISO 4017; BoltType: DIN 933 (ISO 4017); BoltGrade: 8.8; BoltDiameter: 12 mm; BoltLength: 55 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt#6 (26)
In: Default Storey
NominalDiameter: 16 mm
AISC_EM11_Pset_Bolt - BoltDiameter: 16 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalLength (mm) = BoltLength (mm) | BoltStandard | BoltType | BoltGrade
 | 55 | DIN 6914 | 6914 | 10.9
24 x  | 45 | ISO 4017 | DIN 933 (ISO 4017) | 8.8
 | 75 | DIN 6914 | 6914 | 10.9

# IfcMember: - (24)
In: Default Storey
Description: RD22; Material: S235JR
Pset_MemberCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Reference = PieceMark | Span (mm)
2 x - | 22 | 3558.71
2 x - | 26 | 3152.49
2 x - | 24 | 3695.89
2 x - | 23 | 3558.71
2 x - | 25 | 3695.89
2 x - | 27 | 3152.49
2 x - | 28 | 3149.75
2 x - | 29 | 3149.75
2 x - | 30 | 3154.14
2 x - | 31 | 3154.14
2 x - | 32 | 3145.92
2 x - | 33 | 3145.92

# IfcMember: Gel?nder (24)
In: Default Storey
Description: RO42.4X3.2; Material: S235JR
Pset_MemberCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Reference = PieceMark | Span (mm)
Gel?nder | 78 | 3228.48
Gel?nder | 77 | 2886
Gel?nder | 76 | 3191.65
Gel?nder | 75 | 2873.83
Gel?nder | 74 | 2259.66
Gel?nder | 73 | 2259.66
Gel?nder | 72 | 2258.18
Gel?nder | 71 | 2258.18
Gel?nder | 69 | 2260.56
Gel?nder | 70 | 2260.56
Gel?nder | 68 | 2256.1
Gel?nder | 67 | 2256.1
Gel?nder | 81 | 3228.48
Gel?nder | 83 | 3191.65
Gel?nder | 85 | 2259.66
Gel?nder | 87 | 2258.18
Gel?nder | 89 | 2260.56
Gel?nder | 91 | 2256.1
Gel?nder | 82 | 2886
Gel?nder | 84 | 2873.83
Gel?nder | 86 | 2259.66
Gel?nder | 88 | 2258.18
Gel?nder | 90 | 2260.56
Gel?nder | 92 | 2256.1

# IfcPlate: - (68)
In: Default Storey
Description: -
Pset_PlateCommon - IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Material | Reference = PieceMark
8 x - | S235JR 12 mm | 117
48 x - | S235JR 15 mm | 112
12 x - | S235JR 10 mm | 116

# IfcPlate: BottomCoverGrate (22)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Reference = PieceMark
5 x BottomCoverGrate | 96
4 x BottomCoverGrate | 98
BottomCoverGrate | 109
2 x BottomCoverGrate | 104
2 x BottomCoverGrate | 105
4 x BottomCoverGrate | 102
4 x BottomCoverGrate | 101

# IfcPlate: Grate_Step#1 (12)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - Reference: 94; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: 94; MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcPlate: Grate_Step#15 (12)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - Reference: 94; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: 94; MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcPlate: Grate_Step#22 (12)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - Reference: 94; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: 94; MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcPlate: Grate_Step#29 (12)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - Reference: 94; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: 94; MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcPlate: Grate_Step#36 (12)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - Reference: 94; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: 94; MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcPlate: Grate_Step#43 (4)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - Reference: 94; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: 94; MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcPlate: Grate_Step#50 (4)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - Reference: 94; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: 94; MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcPlate: Grate_Step#57 (2)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - Reference: 94; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: 94; MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcPlate: Grate_Step#8 (12)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - Reference: 94; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: 94; MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcPlate: TopCoverGrate (23)
In: Default Storey
Description: -; Material: S235JR 40 mm
Pset_PlateCommon - IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Reference = PieceMark
2 x TopCoverGrate | 103
TopCoverGrate | 107
6 x TopCoverGrate | 95
TopCoverGrate | 108
5 x TopCoverGrate | 97
4 x TopCoverGrate | 99
4 x TopCoverGrate | 100
