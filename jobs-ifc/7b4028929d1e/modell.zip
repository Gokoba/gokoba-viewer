Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[SteelFabricationView]
File name: Technikzentrale auf Klinikdach Ostfildern_em11.ifc
Time: 2026-07-12T18:15:56
Organization: medius KLINIKEN gGmbH
Written by: IFC Toolkit 2.0.26.0
Made in: Advance Steel 2024

# IfcBuildingStorey, Default Storey
In: Struktur 1
Elevation: 0 mm

# IfcBeam: - (99)
In: Default Storey
Material: S235JR
Pset_BeamCommon - Reference: nicht definiert; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]
Name | Description | Span (mm)
7 x - | HEA120 | 3620
5 x - | HEA120 | 3263.2
4 x - | HEA120 | 2276
2 x - | L250X90X10 | 3660
- | L250X90X10 | 3698.89
- | L250X90X10 | 3208.02
2 x - | L250X90X10 | 3290
- | L250X90X10 | 3286.5
- | L250X90X10 | 3166.13
2 x - | L250X90X10 | 3140
- | L250X90X10 | 3143.5
- | L250X90X10 | 3300.16
- | L250X90X10 | 284.316
- | L250X90X10 | 955.853
- | L250X90X10 | 1610
3 x - | L250X90X10 | 3700
2 x - | Q120X4 | 3290
4 x - | Q120X4 | 3140
2 x - | HEA120 | 263.998
2 x - | HEA160 | 3775
2 x - | HEA160 | 3778
2 x - | HEA160 | 3258
- | HEA120 | 3246.5
2 x - | HEA120 | 3250
- | HEA120 | 3268.5
- | HEA120 | 3118.5
2 x - | HEA120 | 3100
- | HEA120 | 3126.13
2 x - | HEA120 | 3235.25
- | HEA120 | 3253.4
- | HEA120 | 3253.42
- | HEA120 | 3617
- | HEA120 | 3096.5
- | HEA120 | 3144.29
- | HEA120 | 3635.16
3 x - | HEA120 | 3264
9 x - | HEA120 | 3784
- | HEA120 | 2225.64
2 x - | HEA120 | 3781
2 x - | HEA120 | 3290.13
2 x - | HEA120 | 3401.75
- | RHS100X80X4 | 1585.5
- | L250X90X10 | 334.998
- | L250X90X10 | 1230
- | L250X90X10 | 516.498
- | HEA 100 | 9102
- | HEA 100 | 7985
2 x - | HEA120 | 3107.88
- | HEA120 | 3489
- | HEA120 | 2998.13
2 x - | HEA120 | 3115.5
- | L250X90X10 | 3293.5
- | L250X90X10 | 3275.25
- | L250X90X10 | 1490.25
- | L250X90X10 | 3697

# IfcColumn: - (51)
In: Default Storey
Material: S235JR
Pset_ColumnCommon - Reference: nicht definiert; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]
Name | Description
15 x - | Q120X4
2 x - | FL55X6
24 x - | HEA140
6 x - | HEA 100
2 x - | RHS100X80X4
- | L100X10
- | R120X60X4

# IfcColumn: AnchorBeam (10)
In: Default Storey
Material: S235JR
Pset_ColumnCommon - Reference: nicht definiert; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]
Name | Description
7 x AnchorBeam | IPE180
3 x AnchorBeam | IPE100

# IfcFastener: Weld (1316)
In: Default Storey
AISC_EM11_Pset_Weld - a: 0 mm; l: 0 mm; WeldDescription: Weld; FieldWeld: no
Name | Type1 | s (mm)
531 x  | Kehlnaht | 4
20 x  | HV | 7
25 x  | Kehlnaht | 7
153 x  | Kehlnaht | 3
166 x  | Kehlnaht | 5
46 x  | Kehlnaht | 6
68 x  | HV | 8
2 x  | Kehlnaht | 8
80 x  | Doppel-Kehlnaht | 6
44 x  | Doppel-Kehlnaht | 5
118 x  | Doppel-Kehlnaht | 3
53 x  | Doppel-Kehlnaht | 4
10 x  | HV | 6

# IfcMechanicalFastener: - (267)
In: Default Storey
Name | NominalDiameter (mm) | NominalLength (mm) | BoltStandard | BoltType | BoltGrade | BoltDiameter (mm) | BoltLength (mm) | BoltFieldAssembled | SequentialOrder
106 x  | 27 | 70 | DIN 6914 | 6914 | 10.9 | 27 | 70 | yes | Feuerverzinkt
24 x  | 30 | 75 | DIN 6914 | 6914 | 10.9 | 30 | 75 | yes | Feuerverzinkt
48 x  | 30 | 80 | DIN 6914 | 6914 | 10.9 | 30 | 80 | yes | Feuerverzinkt
16 x  | 12 | 35 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | 12 | 35 | yes | Feuerverzinkt
25 x  | 10 | 110 |  |  |  |  |  |  | Edelstahl A4
2 x  | 16 | 50 | DIN 6914 | 6914 | 10.9 | 16 | 50 | yes | Feuerverzinkt
12 x  | 10 | 35 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | 10 | 35 | yes | Feuerverzinkt
29 x  | 12 | 30 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | 12 | 30 | yes | Feuerverzinkt
5 x  | 16 | 45 | ISO 4017 | DIN 933 (ISO 4017) | 8.8 | 16 | 45 | yes | Feuerverzinkt

# IfcMechanicalFastener: Anchor_Bolt#1 (29)
In: Default Storey
NominalDiameter: 10 mm; NominalLength: 120 mm
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt

# IfcMechanicalFastener: Bolt (33)
In: Default Storey
NominalDiameter: 12 mm
AISC_EM11_Pset_Bolt - BoltStandard: DIN 6914; BoltType: 6914; BoltGrade: 10.9; BoltDiameter: 12 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalLength (mm) = BoltLength (mm)
22 x  | 60
4 x  | 50
2 x  | 55
5 x  | 40

# IfcMechanicalFastener: Bolt#1 (122)
In: Default Storey
AISC_EM11_Pset_Bolt - BoltStandard: DIN 6914; BoltType: 6914; BoltGrade: 10.9; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalDiameter (mm) = BoltDiameter (mm) | NominalLength (mm) = BoltLength (mm)
2 x  | 20 | 95
6 x  | 16 | 70
2 x  | 20 | 85
64 x  | 12 | 55
19 x  | 12 | 45
16 x  | 12 | 65
5 x  | 12 | 40
8 x  | 12 | 50

# IfcMechanicalFastener: Bolt#2 (143)
In: Default Storey
AISC_EM11_Pset_Bolt - BoltStandard: DIN 6914; BoltType: 6914; BoltGrade: 10.9; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalDiameter (mm) = BoltDiameter (mm) | NominalLength (mm) = BoltLength (mm)
2 x  | 20 | 95
6 x  | 16 | 70
2 x  | 20 | 85
66 x  | 12 | 55
7 x  | 12 | 45
16 x  | 12 | 65
22 x  | 12 | 60
12 x  | 12 | 50
10 x  | 12 | 40

# IfcMechanicalFastener: Bolt#3 (19)
In: Default Storey
NominalDiameter: 12 mm
AISC_EM11_Pset_Bolt - BoltStandard: DIN 6914; BoltType: 6914; BoltGrade: 10.9; BoltDiameter: 12 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalLength (mm) = BoltLength (mm)
16 x  | 65
3 x  | 55

# IfcMechanicalFastener: Bolt#4 (19)
In: Default Storey
NominalDiameter: 12 mm
AISC_EM11_Pset_Bolt - BoltStandard: DIN 6914; BoltType: 6914; BoltGrade: 10.9; BoltDiameter: 12 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalLength (mm) = BoltLength (mm)
16 x  | 65
3 x  | 55

# IfcMechanicalFastener: Bolt#5 (15)
In: Default Storey
NominalDiameter: 12 mm
AISC_EM11_Pset_Bolt - BoltStandard: DIN 6914; BoltType: 6914; BoltGrade: 10.9; BoltDiameter: 12 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalLength (mm) = BoltLength (mm)
4 x  | 55
5 x  | 40
5 x  | 45
 | 50

# IfcMechanicalFastener: Bolt#6 (15)
In: Default Storey
NominalDiameter: 12 mm
AISC_EM11_Pset_Bolt - BoltStandard: DIN 6914; BoltType: 6914; BoltGrade: 10.9; BoltDiameter: 12 mm; BoltFieldAssembled: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: Feuerverzinkt
Name | NominalLength (mm) = BoltLength (mm)
4 x  | 55
5 x  | 40
5 x  | 45
 | 50

# IfcMember: - (84)
In: Default Storey
Material: S235JR
Pset_MemberCommon - Reference: nicht definiert; Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]
Name | Description | Span (mm)
8 x - | FL80X15 | 6675.66
- | FL80X15 | 6652.4
8 x - | FL80X15 | 3007.41
2 x - | FL80X15 | 6383.48
2 x - | FL80X15 | 6394.78
- | FL80X15 | 6655.32
8 x - | FL80X15 | 3695.56
6 x - | IPE600 | 13937.3
2 x - | IPE600 | 12899.4
- | IPE270 | 13927.4
5 x - | HEA120 | 1566.47
- | HEA120 | 1563.97
6 x - | HEA160 | 1440
- | FL80X15 | 6443.73
2 x - | FL80X15 | 3129.68
- | FL80X15 | 1419.96
- | FL80X15 | 1420.03
2 x - | FL80X15 | 3020.87
2 x - | FL80X15 | 2965.29
2 x - | FL80X15 | 3362.76
2 x - | FL80X15 | 3441.61
2 x - | FL80X15 | 3147.92
2 x - | FL80X15 | 3314.67
2 x - | FL80X15 | 2758.09
2 x - | FL80X15 | 2909.94
- | FL80X15 | 2884.59
- | FL80X15 | 2923.8
- | FL80X15 | 3069.82
- | FL80X15 | 3069.79
- | FL80X15 | 2946.65
- | FL80X15 | 2988.21
2 x - | FL80X15 | 3066.86
- | HEA500 | 15635.4
2 x - | HEA220 | 6234.64
- | FL80X15 | 6440.57

# IfcPlate: - (233)
In: Default Storey
Description: -
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]
Name | Material
124 x - | S235JR 15 mm
32 x - | S235JR 8 mm
53 x - | S235JR 10 mm
5 x - | S235JR 6 mm
13 x - | S235JR 20 mm
6 x - | S235JR 12 mm

# IfcPlate: Baseplate (37)
In: Default Storey
Description: -
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]
Name | Material
8 x Baseplate | S235JR 10 mm
29 x Baseplate | S235JR 15 mm

# IfcPlate: Coverplate (24)
In: Default Storey
Description: -; Material: S235JR 10 mm
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]

# IfcPlate: Endplate (103)
In: Default Storey
Description: -
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]
Name | Material
11 x Endplate | S235JR 10 mm
5 x Endplate | S235JR 15 mm
63 x Endplate | S235JR 12 mm
24 x Endplate | S235JR 20 mm

# IfcPlate: Endplate#1 (76)
In: Default Storey
Description: -
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]
Name | Material
2 x Endplate#1 | S235JR 30 mm
6 x Endplate#1 | S235JR 20 mm
2 x Endplate#1 | S235JR 25 mm
59 x Endplate#1 | S235JR 15 mm
7 x Endplate#1 | S235JR 12 mm

# IfcPlate: Endplate#2 (11)
In: Default Storey
Description: -
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]
Name | Material
2 x Endplate#2 | S235JR 30 mm
6 x Endplate#2 | S235JR 20 mm
2 x Endplate#2 | S235JR 25 mm
Endplate#2 | S235JR 15 mm

# IfcPlate: LugPlate#1 (6)
In: Default Storey
Description: -; Material: S235JR 15 mm
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]

# IfcPlate: LugPlate#2 (6)
In: Default Storey
Description: -; Material: S235JR 15 mm
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]

# IfcPlate: Stiffener#1 (7)
In: Default Storey
Description: -; Material: S235JR 10 mm
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]

# IfcPlate: Stiffener#2 (41)
In: Default Storey
Description: -; Material: S235JR 10 mm
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]

# IfcPlate: T-plate (63)
In: Default Storey
Description: -
Pset_PlateCommon - Reference: nicht definiert; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - PieceMark: nicht definiert; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: grundiert + farbl. beschichtet [C2]
Name | Material
56 x T-plate | S235JR 15 mm
7 x T-plate | S235JR 12 mm
