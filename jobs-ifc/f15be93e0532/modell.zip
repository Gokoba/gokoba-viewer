Properties of the parts of a building model (IFC2X3), part 1 of 3

# File
Description: ViewDefinition[SteelFabricationView]
File name: Treppenturm an Kinderklinik N?rnberg_em11.ifc
Time: 2026-07-11T21:29:14
Written by: IFC Toolkit 2.0.26.0
Made in: Advance Steel 2024

# IfcBuildingStorey, Default Storey
In: Struktur 1
Elevation: 0 mm

# IfcBeam: Gel?nder (13)
In: Default Storey
Description: RO42.4X3.2; Material: S235JR
Pset_BeamCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Reference = PieceMark | Span (mm)
Gel?nder | 80 | 2854.8
Gel?nder | 79 | 1242.04
5 x Gel?nder | 66 | 2854.8
5 x Gel?nder | 65 | 1242.04
Gel?nder | 93 | 1847

# IfcBeam: Girder (45)
In: Default Storey
Material: S235JR
Pset_BeamCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Description | Reference = PieceMark | Span (mm)
5 x Girder | U100 | 34 | 1139
Girder | IPE240 | 20 | 3963.5
Girder | U240 | 39 | 1605
Girder | U240 | 40 | 1260
11 x Girder | HEA200 | 17 | 2940
Girder | HEA200 | 18 | 2940
12 x Girder | RO82.5x3.2 (Mannesmann) | 21 | 3363.5
5 x Girder | U240 | 35 | 3120
Girder | U240 | 37 | 2950
Girder | U240 | 38 | 2900
5 x Girder | U240 | 36 | 2900
Girder | IPE240 | 19 | 1596.75

# IfcBeam: Stringer (24)
In: Default Storey
Description: U240; Material: S235JR
Pset_BeamCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Reference = PieceMark | Span (mm)
Stringer | 54 | 1960.42
Stringer | 53 | 1960.42
Stringer | 50 | 1960.32
Stringer | 49 | 1960.32
Stringer | 57 | 1960.25
Stringer | 58 | 1960.25
Stringer | 61 | 1960.57
Stringer | 62 | 1960.57
Stringer | 56 | 1960.42
Stringer | 55 | 1960.42
Stringer | 60 | 1960.25
Stringer | 59 | 1960.25
Stringer | 64 | 1960.57
Stringer | 63 | 1960.57
Stringer | 52 | 1960.32
Stringer | 51 | 1960.32
Stringer | 46 | 1441.89
Stringer | 45 | 1441.89
Stringer | 42 | 1441.18
Stringer | 41 | 1441.18
Stringer | 43 | 1961.18
Stringer | 44 | 1961.18
Stringer | 48 | 1961.89
Stringer | 47 | 1961.89

# IfcColumn: Column (16)
In: Default Storey
Description: HEA200; Material: S235JR
Pset_ColumnCommon - Slope: 0 deg; IsExternal: no; LoadBearing: no
AISC_EM11_Pset_PieceIdentification - MainPieceTag: yes; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | Reference = PieceMark
Column | 2
Column | 1
Column | 3
Column | 4
Column | 5
Column | 6
Column | 7
Column | 8
Column | 9
Column | 10
Column | 11
Column | 12
Column | 13
Column | 14
Column | 15
Column | 16

# IfcDiscreteAccessory: - (315)
In: Default Storey
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Description | Material | PieceMark | SequentialOrder
4 x - | HEA120 | S235JR | 300 | feuerverzinkt
30 x - | RO33.7X2.6 | S235JR | 331 | feuerverzinkt
24 x - | RD22 | S235JR | 334 | feuerverzinkt
- | - | S235JR 30 mm | 319 | feuerverzinkt
4 x - | - | S235JR 20 mm | 308 | feuerverzinkt
3 x - | - | S235JR 30 mm | 309 | feuerverzinkt
12 x - | - | S235JR 3 mm | 547 | feuerverzinkt
38 x - | - | S235JR 6 mm | 545 | feuerverzinkt
22 x - | - | S235JR 6 mm | 546 | feuerverzinkt
10 x - | - | S235JR 10 mm | 344 | keine
2 x - | - | S235JR 15 mm | 323 | feuerverzinkt
- | - | S235JR 15 mm | 398 | feuerverzinkt
10 x - | - | S235JR 15 mm | 396 | feuerverzinkt
4 x - | - | S235JR 10 mm | 307 | feuerverzinkt
- | - | S235JR 20 mm | 318 | feuerverzinkt
2 x - | - | S235JR 20 mm | 314 | feuerverzinkt
6 x - | - | S235JR 20 mm | 306 | feuerverzinkt
2 x - | - | S235JR 20 mm | 312 | feuerverzinkt
48 x - | - | S235JR 20 mm | 335 | keine
24 x - | - | S235JR 10 mm | 324 | feuerverzinkt
- | - | S235JR 20 mm | 315 | feuerverzinkt
2 x - | - | S235JR 20 mm | 313 | feuerverzinkt
6 x - | - | S235JR 20 mm | 305 | feuerverzinkt
2 x - | - | S235JR 20 mm | 311 | feuerverzinkt
- | - | S235JR 20 mm | 316 | feuerverzinkt
40 x - | - | S235JR 10 mm | 302 | feuerverzinkt
12 x - | - | S235JR 20 mm | 304 | feuerverzinkt
2 x - | - | S235JR 10 mm | 310 | feuerverzinkt
- | - | S235JR 20 mm | 317 | feuerverzinkt

# IfcDiscreteAccessory: Bar#0 (18)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
8 x Bar#0 | 330
10 x Bar#0 | 328

# IfcDiscreteAccessory: Bar#1 (18)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 330; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Bar#10 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 330; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Bar#11 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Bar#11 | 328
5 x Bar#11 | 330

# IfcDiscreteAccessory: Bar#12 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 328; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Bar#13 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 328; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Bar#14 (5)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 328; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Bar#2 (18)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
9 x Bar#2 | 330
9 x Bar#2 | 328

# IfcDiscreteAccessory: Bar#3 (10)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 328; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Bar#4 (7)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 328; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Bar#5 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 328; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Bar#6 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 328; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Bar#7 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 328; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Bar#8 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Bar#8 | 330
5 x Bar#8 | 328

# IfcDiscreteAccessory: Bar#9 (6)
In: Default Storey
Description: RD12; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Bar#9 | 330
4 x Bar#9 | 328

# IfcDiscreteAccessory: Baseplate (2)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 397; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: BottomLanding#1 (11)
In: Default Storey
Description: U240; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
4 x BottomLanding#1 | 355
4 x BottomLanding#1 | 352
BottomLanding#1 | 386
BottomLanding#1 | 388
BottomLanding#1 | 390

# IfcDiscreteAccessory: BottomLanding#2 (11)
In: Default Storey
Description: U240; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
4 x BottomLanding#2 | 354
4 x BottomLanding#2 | 353
BottomLanding#2 | 387
BottomLanding#2 | 389
BottomLanding#2 | 391

# IfcDiscreteAccessory: BottomLanding#3 (22)
In: Default Storey
Description: L40X4; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
4 x BottomLanding#3 | 351
10 x BottomLanding#3 | 347
2 x BottomLanding#3 | 356
BottomLanding#3 | 361
BottomLanding#3 | 360
2 x BottomLanding#3 | 358
2 x BottomLanding#3 | 357

# IfcDiscreteAccessory: Endplate (75)
In: Default Storey
Description: -
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
Name | Material | PieceMark | SequentialOrder
3 x Endplate | S235JR 20 mm | 322 | feuerverzinkt
24 x Endplate | S235JR 10 mm | 321 | keine
48 x Endplate | S235JR 10 mm | 394 | feuerverzinkt

# IfcDiscreteAccessory: Endplate#1 (12)
In: Default Storey
Description: -; Material: S235JR 25 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 303; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: keine

# IfcDiscreteAccessory: Endplate#2 (12)
In: Default Storey
Description: -; Material: S235JR 25 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 303; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: keine

# IfcDiscreteAccessory: Grate_Step#10 (12)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#16 (12)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#17 (12)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#2 (12)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#23 (12)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#24 (12)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#3 (12)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#30 (12)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#31 (12)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#37 (12)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#38 (12)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#44 (4)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#45 (4)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#51 (4)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#52 (4)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#58 (2)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#59 (2)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Grate_Step#9 (12)
In: Default Storey
Description: -; Material: S235JR 3 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 602; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#500 (18)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#501 (18)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#502 (18)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#503 (10)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#504 (7)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#505 (6)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#506 (6)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#507 (6)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#508 (6)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#509 (6)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#510 (6)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#511 (6)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#512 (6)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#513 (6)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Plate#514 (5)
In: Default Storey
Description: -; Material: S235JR 20 mm
AISC_EM11_Pset_PieceIdentification - PieceMark: 544; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Handrail_Landing#0 (9)
In: Default Storey
Description: RO42.4X3.2; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Railing_Handrail_Landing#0 | 477
5 x Railing_Handrail_Landing#0 | 425
2 x Railing_Handrail_Landing#0 | 474

# IfcDiscreteAccessory: Railing_Handrail_Landing#2 (16)
In: Default Storey
Description: RO42.4X3.2; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Handrail_Landing#2 | 534
4 x Railing_Handrail_Landing#2 | 446
Railing_Handrail_Landing#2 | 533
4 x Railing_Handrail_Landing#2 | 401
Railing_Handrail_Landing#2 | 475
Railing_Handrail_Landing#2 | 476
4 x Railing_Handrail_Landing#2 | 404

# IfcDiscreteAccessory: Railing_Handrail_Landing#3 (3)
In: Default Storey
Description: RO42.4X3.2; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Handrail_Landing#3 | 475
Railing_Handrail_Landing#3 | 528
Railing_Handrail_Landing#3 | 530

# IfcDiscreteAccessory: Railing_Handrail_Landing#4 (24)
In: Default Storey
Description: RO42.4X3.2; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Handrail_Landing#4 | 476
4 x Railing_Handrail_Landing#4 | 404
5 x Railing_Handrail_Landing#4 | 401
4 x Railing_Handrail_Landing#4 | 444
5 x Railing_Handrail_Landing#4 | 424
Railing_Handrail_Landing#4 | 526
Railing_Handrail_Landing#4 | 535
Railing_Handrail_Landing#4 | 532
Railing_Handrail_Landing#4 | 339
Railing_Handrail_Landing#4 | 340

# IfcDiscreteAccessory: Railing_Handrail_Landing#5 (22)
In: Default Storey
Description: RO42.4X3.2; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Handrail_Landing#5 | 531
Railing_Handrail_Landing#5 | 527
10 x Railing_Handrail_Landing#5 | 339
10 x Railing_Handrail_Landing#5 | 340

# IfcDiscreteAccessory: Railing_Handrail_Landing#6 (10)
In: Default Storey
Description: RO42.4X3.2; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
5 x Railing_Handrail_Landing#6 | 423
Railing_Handrail_Landing#6 | 529
4 x Railing_Handrail_Landing#6 | 445

# IfcDiscreteAccessory: Railing_Handrail_Landing#7 (2)
In: Default Storey
Description: RO42.4X3.2; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Handrail_Landing#7 | 415
Railing_Handrail_Landing#7 | 416

# IfcDiscreteAccessory: Railing_Handrail_Landing#8 (10)
In: Default Storey
Description: RO42.4X3.2; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
5 x Railing_Handrail_Landing#8 | 415
5 x Railing_Handrail_Landing#8 | 416

# IfcDiscreteAccessory: Railing_Kneerail_Landing#0 (25)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
10 x Railing_Kneerail_Landing#0 | 395
5 x Railing_Kneerail_Landing#0 | 338
10 x Railing_Kneerail_Landing#0 | 400

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1 (10)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Railing_Kneerail_Landing#1 | 471
8 x Railing_Kneerail_Landing#1 | 403

# IfcDiscreteAccessory: Railing_Kneerail_Landing#10 (7)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Railing_Kneerail_Landing#10 | 467
5 x Railing_Kneerail_Landing#10 | 333

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1000 (12)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Landing#1000 | 522
Railing_Kneerail_Landing#1000 | 523
4 x Railing_Kneerail_Landing#1000 | 440
2 x Railing_Kneerail_Landing#1000 | 469
4 x Railing_Kneerail_Landing#1000 | 402

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1001 (4)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 402; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1003
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 472; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1004 (3)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Landing#1004 | 441
Railing_Kneerail_Landing#1004 | 507
Railing_Kneerail_Landing#1004 | 466

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1005 (21)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
3 x Railing_Kneerail_Landing#1005 | 441
3 x Railing_Kneerail_Landing#1005 | 419
Railing_Kneerail_Landing#1005 | 472
4 x Railing_Kneerail_Landing#1005 | 431
5 x Railing_Kneerail_Landing#1005 | 345
Railing_Kneerail_Landing#1005 | 490
Railing_Kneerail_Landing#1005 | 519
Railing_Kneerail_Landing#1005 | 468
Railing_Kneerail_Landing#1005 | 332
Railing_Kneerail_Landing#1005 | 337

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1006 (18)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Railing_Kneerail_Landing#1006 | 419
Railing_Kneerail_Landing#1006 | 405
7 x Railing_Kneerail_Landing#1006 | 332
7 x Railing_Kneerail_Landing#1006 | 337
Railing_Kneerail_Landing#1006 | 478

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1007 (6)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
3 x Railing_Kneerail_Landing#1007 | 337
3 x Railing_Kneerail_Landing#1007 | 332

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1008 (3)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 405; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1011 (3)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Railing_Kneerail_Landing#1011 | 405
Railing_Kneerail_Landing#1011 | 504

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1012 (6)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
3 x Railing_Kneerail_Landing#1012 | 342
Railing_Kneerail_Landing#1012 | 506
2 x Railing_Kneerail_Landing#1012 | 432

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1014 (4)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Railing_Kneerail_Landing#1014 | 342
2 x Railing_Kneerail_Landing#1014 | 432

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1018 (8)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
4 x Railing_Kneerail_Landing#1018 | 406
4 x Railing_Kneerail_Landing#1018 | 410

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1019
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 407; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1020 (4)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Railing_Kneerail_Landing#1020 | 406
2 x Railing_Kneerail_Landing#1020 | 410

# IfcDiscreteAccessory: Railing_Kneerail_Landing#1021 (5)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 407; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Landing#11 (6)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Landing#11 | 508
5 x Railing_Kneerail_Landing#11 | 421

# IfcDiscreteAccessory: Railing_Kneerail_Landing#12 (5)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 342; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Landing#13 (5)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Landing#13 | 509
4 x Railing_Kneerail_Landing#13 | 333

# IfcDiscreteAccessory: Railing_Kneerail_Landing#14 (4)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 439; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Landing#16
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 497; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Landing#17
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 495; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Landing#18 (6)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Landing#18 | 412
Railing_Kneerail_Landing#18 | 502
4 x Railing_Kneerail_Landing#18 | 435

# IfcDiscreteAccessory: Railing_Kneerail_Landing#19 (6)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Landing#19 | 408
5 x Railing_Kneerail_Landing#19 | 417

# IfcDiscreteAccessory: Railing_Kneerail_Landing#20 (5)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 412; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Landing#21 (5)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 408; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Landing#22 (12)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
6 x Railing_Kneerail_Landing#22 | 338
6 x Railing_Kneerail_Landing#22 | 409

# IfcDiscreteAccessory: Railing_Kneerail_Landing#3
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - PieceMark: 414; MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt

# IfcDiscreteAccessory: Railing_Kneerail_Landing#4 (10)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Landing#4 | 505
Railing_Kneerail_Landing#4 | 473
4 x Railing_Kneerail_Landing#4 | 414
3 x Railing_Kneerail_Landing#4 | 420
Railing_Kneerail_Landing#4 | 517

# IfcDiscreteAccessory: Railing_Kneerail_Landing#5 (19)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Landing#5 | 466
Railing_Kneerail_Landing#5 | 521
4 x Railing_Kneerail_Landing#5 | 436
Railing_Kneerail_Landing#5 | 414
4 x Railing_Kneerail_Landing#5 | 442
2 x Railing_Kneerail_Landing#5 | 420
3 x Railing_Kneerail_Landing#5 | 422
Railing_Kneerail_Landing#5 | 468
Railing_Kneerail_Landing#5 | 332
Railing_Kneerail_Landing#5 | 411

# IfcDiscreteAccessory: Railing_Kneerail_Landing#6 (24)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Landing#6 | 514
5 x Railing_Kneerail_Landing#6 | 333
Railing_Kneerail_Landing#6 | 473
2 x Railing_Kneerail_Landing#6 | 422
7 x Railing_Kneerail_Landing#6 | 332
4 x Railing_Kneerail_Landing#6 | 411
3 x Railing_Kneerail_Landing#6 | 337
Railing_Kneerail_Landing#6 | 510

# IfcDiscreteAccessory: Railing_Kneerail_Landing#7 (13)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Landing#7 | 462
5 x Railing_Kneerail_Landing#7 | 345
Railing_Kneerail_Landing#7 | 493
2 x Railing_Kneerail_Landing#7 | 337
3 x Railing_Kneerail_Landing#7 | 332
Railing_Kneerail_Landing#7 | 411

# IfcDiscreteAccessory: Railing_Kneerail_Landing#8 (8)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Landing#8 | 338
Railing_Kneerail_Landing#8 | 462
5 x Railing_Kneerail_Landing#8 | 418
Railing_Kneerail_Landing#8 | 518

# IfcDiscreteAccessory: Railing_Kneerail_Landing#9 (6)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
Railing_Kneerail_Landing#9 | 511
5 x Railing_Kneerail_Landing#9 | 333

# IfcDiscreteAccessory: Railing_Kneerail_Stair#1 (10)
In: Default Storey
Description: FL60X10; Material: S235JR
AISC_EM11_Pset_PieceIdentification - MainPieceTag: no; PrelimMark: nicht definiert
AISC_EM11_Pset_ToleranceForLayout - LayoutTolerance: 0.001 mm
AISC_EM11_Pset_Material - MaterialID: S235JR; MaterialType: Steel
AISC_EM11_Pset_StatusInformation - Status: Default; ChangeStatus: Default; StatusApproved: yes
AISC_EM11_Pset_SurfaceTreatment - SequentialOrder: feuerverzinkt
Name | PieceMark
2 x Railing_Kneerail_Stair#1 | 470
Railing_Kneerail_Stair#1 | 433
Railing_Kneerail_Stair#1 | 482
6 x Railing_Kneerail_Stair#1 | 413
